# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LAN_MDI3N: length 23.6
  TOP w0.089: UL1.10 27.24,84.61 28.03,83.83 v2(28.03,82.47)
  BOTTOM w0.089: v2(28.03,82.47) 28.03,81.81 28.12,81.72 28.12,80.9 28.67,80.34 28.67,71.34 28.57,71.24 28.57,66.71 27.69,65.83 27.69,64.82 27.31,64.44 26.84,64.44 26.79,64.38 26.79,64.28 26.75,64.24 TL2.16
LAN_MDI3P: length 23.6
  TOP w0.089: UL1.9 26.92,84.21 27.04,84.33 27.12,84.33 27.74,83.71 27.74,82.77 v2(27.44,82.47)
  BOTTOM w0.089: v2(27.44,82.47) 27.46,82.47 27.74,82.18 27.74,81.69 27.84,81.6 27.84,80.78 28.39,80.23 28.39,71.45 28.29,71.36 28.29,66.82 27.41,65.94 27.41,64.94 27.19,64.72 26.87,64.72 26.75,64.83 26.75,65.46 26.7,65.51 TL2.15
LANWAKE#: length 166.6
  TOP w0.102: v2(119.95,67.36) 119.96,67.37 RC85.2 ; v2(36.24,63.36) 36,63.12 UE1.35
  IN1 w0.076: v2(119.95,67.36) 119.62,67.69 116.37,67.69 115.73,67.05
  IN1 w0.127: 115.73,67.05 115.1,66.42 115.1,65.46 114.97,65.34 114.49,65.34 111.12,61.96 111.02,61.96 110.65,61.59 110.55,61.59 108.32,59.37 105.57,59.37 104.41,58.21 102.69,58.21 102.65,58.17 102.65,56.45 99.51,53.31 99.51,51.58 96.95,49.02 93.92,49.02 92.67,47.77 90.59,47.77 85.36,42.54 68.21,42.54 67.95,42.79 62.06,42.79 57.56,47.3 57.56,60.12 56.17,61.51 56.17,70.61 55.6,71.19 55.6,81.59 v2(54.33,82.86) ; v2(34.98,86.01) 34.55,86.01 31.56,83.02 31.56,80.48 36.39,75.65 36.39,71.34 35.66,70.61 35.66,70.23 36.24,69.64 v2(36.24,63.36)
  IN2 w0.127: v2(54.33,82.86) 54.33,84.7 52.27,86.76 35.73,86.76 v2(34.98,86.01)
  BOTTOM w0.076: UC1.AM15 120.29,67.69 v2(119.95,67.36)
LANXIN: length 2.7
  TOP w0.102: UL1.28 21.77,85.81 v1(21.04,86.55) 20.83,86.76 RL8.2
LANXIN_R: length 5.3
  TOP w0.102: YL1.1 17.32,86.29 18.48,86.29 18.77,86.58 18.77,87.21 CL10.1 RL8.1
LANXOUT: length 2.6
  TOP w0.102: UL1.29 21.36,85.41 v1(21.22,85.28) 21.11,85.28 20.52,85.87 RL9.2
LANXOUT_R: length 2.3
  TOP w0.102: RL9.1 CL11.1 18.14,84.98 YL1.3
LCD_BRIGHTNESS: length 5.7
  TOP w0.102: RP2.2 214.54,50.9 v2(214.38,51.06)
  BOTTOM w0.102: v2(214.38,51.06) 214.69,50.75 214.69,50.31 213.73,49.35 213.73,48.25 212.93,47.45 JEDP1.27
LCD_CBL_DET#: length 120.8
  TOP w0.102: v2(127.85,58.68) 127.85,58.63 128.23,58.25 RC205.1 v1(128.58,57.29)
  IN1 w0.127: v2(127.85,58.68) 127.97,58.56 128.66,58.56 129.94,59.84 135.64,59.84 136.05,59.43 140.77,59.43 143.21,56.99 148.34,56.99 149.47,55.86 149.47,48.17 151.39,46.25 151.39,45.93 154.53,42.79 158.44,42.79 160.06,41.17 169.83,41.17 172.52,38.48 173.89,37.1 175.22,37.1 175.72,37.6 182.67,37.6 182.89,37.82 186.8,37.82 187.68,38.69 191.38,38.69 192.01,38.06 200.72,38.06 208.32,45.65 208.32,46.61 208.85,47.15 209.41,47.15 211.29,45.27 212.06,45.27 212.7,45.91 212.7,51.56 213.79,52.65 v2(213.79,53.22)
  BOTTOM w0.076: v2(127.85,58.68) 127.72,58.68 126.82,59.58 126.82,59.79 126.78,59.88 126.78,60 126.84,60.09 126.84,60.36 126.74,60.59 126.74,60.98 126.41,61.32 UC1.W4
  BOTTOM w0.102: JEDP1.14 213.06,53.95 v2(213.79,53.22)
LCD_TST: length 260
  TOP w0.102: UE1.26 34.49,65.63 v2(34.86,66) ; v1(221.75,50.35) 221.47,50.07 D3.3 220.2,50.85 220.06,50.99 v2(219.49,50.99) 219.35,51.12 218.09,51.12 217.37,50.4 RP2.6
  IN1 w0.127: v2(219.49,50.99) 220.9,49.58 220.9,33.79 220.58,33.47 218.84,33.47 218.14,34.17 218.14,38.41 217.31,39.25 212.65,39.25 210.17,36.77 210.17,34.7 207.78,32.32 205.9,32.32 204.47,30.89 182.27,30.89 179.89,28.51 158.81,28.51 158.12,27.82 146.16,27.82 143.16,30.82 139.65,30.82 135.65,26.83 120.33,26.83 119.22,27.94 114.92,27.94 113.51,26.53 105.76,26.53 103.71,28.58 101.58,28.58 100.24,27.24 99.15,27.24 97.85,25.94 84.17,25.94 83.28,26.83 57.71,26.83 55.24,29.29 54.3,29.29 49.26,34.34 44.57,34.34 37.08,41.83 37.08,52.6 32.97,56.71 32.97,64.11 v2(34.86,66)
LCD_TST_C: length 8
  TOP w0.102: RP2.3 214.36,50.4 v2(214.28,50.48)
  BOTTOM w0.102: JEDP1.10 213.07,55.95 213.33,55.68 213.84,55.68 214.28,55.24 214.28,52.76 213.98,52.46 213.98,50.79 v2(214.28,50.48)
LCD_VCC_TEST_EN: length 239.1
  TOP w0.102: v2(217.2,49.84) 216.96,49.6 215.45,49.6 214.71,48.87 213.03,48.87 211.61,50.29 210.8,50.29 210.4,50.69 D4.3 210.4,52.84 v1(210.04,53.2) ; UE1.113 v2(41.2,75.85)
  IN1 w0.127: v2(41.2,75.85) 41.2,65.8 42.55,64.46 42.55,61.56 43.16,60.95 43.16,55.36 46.63,51.88 46.63,45.43 56.67,35.4 60.68,35.4 62.56,33.52 90.85,33.52 91.93,34.6 101.66,34.6 102.65,33.62 129.34,33.62 135.28,39.56 150.36,39.56 154.3,35.62 157.01,35.62 160.29,32.34 179.91,32.34 181.01,33.43 192.42,33.43 193.68,34.69 203.3,34.69 203.78,35.17 205.15,35.17 205.32,35.34 206.87,35.34 208.42,36.88 208.42,38.46 211.11,41.16 215.61,41.16 217.57,43.12 217.57,49.47 v2(217.2,49.84)
LCDVDD_EN: length 23.3
  TOP w0.102: U1.4 223.17,58.27 R10.1 223.5,57.93 v1(223.5,56.75) 224.01,56.24 224.01,51.57 221.01,48.57 217.78,48.57 216.99,49.36 215.53,49.36 214.81,48.64 211.53,48.64 211.36,48.8 D4.1
LDO1_CAP: length 7.4
  TOP w0.102: RA41.2 21.76,18.16 21.31,18.16 v1(21.17,18.3)
  TOP w0.203: UA1.27 25.83,14.65
  TOP w0.305: RA41.2 23.15,16.77 CA20.2 23.85,16.19 24.1,15.93 24.48,15.93 25.77,14.65 25.83,14.65
LDO2_CAP: length 3
  TOP w0.203: UA1.39 28.38,9.4
  TOP w0.305: 28.38,9.4 28.38,9.32 v1(28.16,9.1) 27.94,8.88 27.46,8.88 26.96,8.38 CA21.2
LDO3_CAP: length 2.6
  TOP w0.203: UA1.7 33.51,13.45
  TOP w0.305: CA22.2 34.96,13.9 34.51,13.45 v1(34.04,13.45) 33.51,13.45
LED1: length 3
  TOP w0.102: v2(21.62,87.03) 22.04,86.61 UL1.26
  BOTTOM w0.102: v1(22.49,86.11) RL17.2
  BOTTOM w0.254: v2(21.62,87.03) 21.62,86.85 21.43,86.66 RL17.2
LG_1.2V: length 2.9
  TOP w0.102: v1(92.16,134.81) 92.54,134.42 v2(92.54,134.41)
  IN2 w0.762: 90.46,136.67 90.46,136.46 91.98,134.93
  vias: v2(90.65,138.04) v2(90.65,137.41) v2(93.02,134.02)
LG_VCCSA: length 6.3
  TOP w0.102: v2(168.56,59.57) v1(168.56,60.1)
  IN2 w0.762: v2(168.56,59.57) 168.56,60.51 167.78,61.29 164.52,61.29 v2(164.17,60.94)
LGATE_CHG: length 7.4
  IN2 w0.762: 196.12,50.35 196.12,48.98 193.49,46.35 192.82,46.35 192.06,45.59
  BOTTOM w0.102: v2(191.04,45.4) v1(191.58,45.4)
  vias: v2(190.41,45.4) v2(196.57,50.99) v2(197.2,50.99)
LID_CL_SIO#: length 226.7
  TOP w0.102: R22.1 v2(218.67,60.7) ; v2(48.02,63.88) 48.27,63.63 UE1.66 50,63.63 50.64,62.99 50.64,61.72 v1(50.99,61.37) 51.32,61.04 CE19.1 RE25.2 ; D5.1 215,46.11 v2(215,46.45)
  IN1 w0.127: v2(48.02,63.88) 48.02,61.31 48.46,60.87 48.46,54.81 48.13,54.47 48.13,53.1 48.76,52.46 48.76,44.92 57.14,36.55 61.32,36.55 63.21,34.66 89.62,34.66 90.06,35.11 109.69,35.11 109.88,34.92 129.03,34.92 134.8,40.7 151,40.7 154.68,37.02 158.08,37.02 161.37,33.74 179.7,33.74 180.59,34.63 183.3,34.63 183.95,35.28 192.4,35.28 193.4,36.28 201.46,36.28 205.48,40.3 209.6,40.3 212.33,43.03 214.18,43.03 215.08,43.94 215.08,44.75 215,44.83 v2(215,46.45) 215.17,46.62 215.17,53.84 218.28,56.95 218.28,60.32 v2(218.67,60.7)
LID_CLOSE#: length 7
  TOP w0.102: v4(219.13,60.33) 219.13,60.97 219.58,61.42 R22.2 EC2902.1 220.19,62.5 v2(220.2,62.51)
  BOTTOM w0.102: v2(220.2,62.51) 220.3,62.4 222.68,62.4 223.2,62.93 JPWR1.3
LINE1-L_C: length 2.4
  TOP w0.102: CA32.2 21.7,20.38 21.12,19.79 v1(21.12,19.74)
  TOP w0.305: RA28.1 22.2,19.38 CA32.2
LINE1-L_R: length 2.1
  TOP w0.102: RA32.1 22.18,23.63 v1(22.25,23.69)
  TOP w0.305: RA32.1 22.2,22.65 CA33.2
LINE1_L: length 6.8
  TOP w0.203: UA1.22 28.38,16.79 28.1,17.08 27.44,17.08 v1(25.07,19.45) 24.14,20.38 CA32.1
LINE1_R: length 8.1
  TOP w0.203: UA1.21 28.78,16.97 28.29,17.46 27.85,17.46 24.67,20.63 v1(24.67,21.2) 24.23,21.65 CA33.1
LOM_TCT: length 16.2
  TOP w0.102: v2(26.95,69.99) 27.4,69.53 28.09,69.53 v1(28.17,69.45)
  TOP w0.508: v2(27.03,67.41) 26.41,66.78 TL1.11 ; TL1.14 26.48,70.59 26.95,70.12 v2(26.95,69.99)
  IN1 w0.508: v2(25.64,62.47) 27.03,63.86 v2(27.03,67.41) 27.03,69.9 v2(26.95,69.99)
  BOTTOM w0.508: TL1.14 26.34,70.59 v2(26.95,69.99) ; CL12.1 v2(25.64,62.47) ; TL1.11 26.41,66.78 v2(27.03,67.41)
LX_1.2V: length 7.8
  TOP w0.102: PRM01.1 v1(86.71,140.19)
  IN2 w0.762: 93.38,135.82 93.38,138.81 92.43,139.76 90.78,139.76
  vias: v2(85.76,138.49) v2(85.76,137.85) v2(89.32,139.63) v2(89.95,139.63) v2(93.38,135.06) v2(93.82,134.62)
LX_1.8VALW: length 1.8
  TOP w0.102: PR1804.1 v1(160.38,48.17)
  vias: v2(163.48,47.22) v2(163.48,46.59)
LX_3V: length 2.7
  TOP w0.102: PR305.1 v1(108.47,135.38)
  BOTTOM w0.254: 107,141.31 106.78,141.52 v2(106.58,141.52) ; 107.03,141.34 PU301.6
  vias: v2(106.4,136.27) v2(106.71,142.09) v2(106.84,136.96) v2(107.03,136.27) v2(107.43,136.96)
LX_5V: length 1.8
  TOP w0.102: PR505.1 v1(158.67,133.85)
  vias: v2(155.61,134.04) v2(155.61,133.41) v2(156.69,140.2) v2(156.74,135.44) v2(157.27,140.2) v2(157.32,135.44)
LX_+1VALW: length 1.5
  TOP w0.102: PRH07.1 v1(161.77,55.67)
  vias: v2(164.75,55.99) v2(164.75,55.35)
LX_VCCSA: length 1.5
  TOP w0.102: PRA02.1 v1(162.21,64.46)
  vias: v2(163.48,63.05) v2(163.48,62.42)
LX_VCORE1: length 1.8
  TOP w0.102: PRI03.1 v1(155.02,79.37)
  vias: v2(156.47,80.31) v2(157.07,80.31)
LX_VCORE2: length 1.4
  TOP w0.102: PRI23.1 v1(152.61,102.29)
  vias: v2(154.97,102.42) v2(154.97,101.79)
LX_VGT1: length 1.8
  TOP w0.102: PRG03.1 v1(147.75,128.52)
  vias: v2(145.58,127.57) v2(146.34,127.57)
M2_SSD_PEDET: length 157.8
  TOP w0.102: v1(20.89,30.23) RS2.1 21.9,30.55 v2(22.38,31.03) ; v2(129.89,25.4) 129.46,25.83 v2(129.46,38.41)
  IN1 w0.127: v2(129.89,25.4) 119.79,25.4 118.64,26.54 114.6,26.54 113.59,25.53 105.55,25.53 103.91,27.18 102.16,27.18 100.67,25.7 100.03,25.7 99.76,25.43 58.03,25.43 54.92,28.53 53.34,28.53 50.32,31.55 39.3,31.55 37,29.24 24.75,29.24 22.96,31.03 v2(22.38,31.03)
  IN2 w0.127: v2(129.46,38.41) 129.87,38.83 129.87,48.89 130.73,49.75 130.73,52.3 132.55,54.13 132.55,55.11 133.49,56.04 133.49,58.76 v2(133.19,59.05)
  BOTTOM w0.076: v2(133.19,59.05) 133.42,59.28 133.42,60.26 133.09,60.59 132.88,60.59 132.74,60.86 132.74,61.25 UC1.G4
  BOTTOM w0.102: JSSD1.69 22.37,31.04 v2(22.38,31.03)
MASK_SATA_LED#: length 90
  TOP w0.102: UE1.56 44.4,60.64 v2(44.17,60.41) 44.17,60.22 RC224.2
  IN1 w0.127: v2(44.17,60.41) 44.17,61.27 42.86,62.58 42.86,64.5 42.23,65.14 42.23,73.2 41.46,73.97 41.46,75.17 41.66,75.37 41.66,82.4 35.78,88.28 35.78,121.85 v2(38.53,124.6)
  BOTTOM w0.102: v2(38.53,124.6) v1(28.11,124.6) R23.2 Q22.2
MCT: length 7
  TOP w0.102: RL14.1 v1(19.85,78.57)
  TOP w0.508: v2(17.69,77.47) RL15.1 RL14.1
  BOTTOM w0.508: v2(17.69,77.47) RL15.1 RL14.1 20.62,77.47 CL13.1
MCT0: length 9.4
  TOP w0.102: v2(17.75,76.07) v1(17.24,76.07)
  TOP w0.254: RL15.2 v2(17.75,76.07) ; v2(18.39,70.23) 18.02,70.59 TL1.3
  IN2 w0.254: v2(18.39,70.23) 17.18,71.43 17.18,75.5 v2(17.75,76.07)
MCT1: length 13.7
  TOP w0.102: v1(21.14,75.85) 20.93,76.07 RL14.2
  TOP w0.254: v2(18.45,67.18) 18.05,66.78 TL1.6 ; v2(19.85,75.4) RL14.2
  IN1 w0.254: v2(19.85,75.4) 19.01,75.4 17.5,73.88 17.5,68.13 v2(18.45,67.18)
MCT2: length 10.3
  TOP w0.102: v1(17.15,77.38) 17.15,77.22 17.61,76.77 v2(18.58,76.77)
  IN2 w0.254: v2(18.45,71.12) 17.81,71.75 17.81,75.31 RL19.2 v2(18.58,76.77)
  BOTTOM w0.254: RL19.2 v2(18.58,76.77) ; TL2.6 17.92,70.59 v2(18.45,71.12)
MCT3: length 15.8
  TOP w0.102: v1(21.09,77.12) 20.74,76.77 v2(19.85,76.77)
  IN1 w0.254: v2(19.85,76.77) 16.89,73.81 16.89,68.04 v2(18.45,66.48)
  BOTTOM w0.254: RL20.2 v2(19.85,76.77) ; v2(18.45,66.48) 18.15,66.78 TL2.3
MDO0+: length 10.6
  TOP w0.267: JLAN1.1 13.47,77.72 14.08,78.33 15.14,78.33 16.04,77.43 16.04,76.89 16.07,76.86 16.07,76.52 16.04,76.49 16.04,76.04 15.34,75.34 15.34,72.8 15.45,72.69 15.89,72.69 16.34,73.13 TL1.1
MDO0-: length 10.5
  TOP w0.267: TL1.2 16.12,71.86 15.67,72.3 15.29,72.3 14.96,72.64 14.96,75.5 15.66,76.2 15.66,76.69 v1(15.63,76.72) 15.63,76.79 15.66,76.82 15.66,77.27 14.98,77.95 14.24,77.95 13.85,77.56 13.85,76.9 JLAN1.2
MDO1+: length 17
  TOP w0.267: TL1.7 16.21,65.51 15.7,65 14.5,65 14.05,65.45 14.05,68.03 v2(14.15,68.13)
  IN1 w0.178: JLAN1.3 14.58,75.68 15.21,75.05 15.66,75.05 15.91,74.8 15.91,72.19 15.32,71.61 15.32,70.09 13.97,68.74 13.97,68.31 v2(14.15,68.13)
MDO1-: length 17
  TOP w0.267: TL1.8 16.46,64.24 16.11,64.59 v1(14.54,64.59) 14.37,64.59 13.67,65.29 13.67,68.03 v2(13.57,68.13)
  IN1 w0.178: JLAN1.6 14.05,73.44 15.36,74.75 15.53,74.75 15.6,74.67 15.6,72.32 15.02,71.74 15.02,70.21 13.67,68.86 13.67,68.23 v2(13.57,68.13)
MDO2+: length 5.1
  BOTTOM w0.267: TL2.8 16.7,73.13 16.15,72.58 15.91,72.58 15.48,73.01 15.48,73.61 15.07,74.02 13.98,74.02 13.76,74.24 13.76,74.48 13.94,74.66 JLAN1.4
MDO2-: length 5.2
  BOTTOM w0.267: JLAN1.5 14.91,73.64 15.1,73.45 15.1,72.85 15.75,72.19 16.38,72.19 16.71,71.86 TL2.7
MDO3+: length 10.6
  BOTTOM w0.267: JLAN1.7 13.81,71.6 13.91,71.7 14.77,71.7 15.4,71.06 15.4,69.15 15.02,68.77 15.02,66.4 15.05,66.37 15.05,65.95 15.02,65.92 15.02,65.56 15.22,65.36 15.95,65.36 16.1,65.51 TL2.2
MDO3-: length 10.5
  BOTTOM w0.267: JLAN1.8 13.9,70.73 13.9,71.15 14.07,71.32 14.61,71.32 15.02,70.91 15.02,69.3 14.64,68.92 v1(14.64,66.12) 14.64,65.37 15.03,64.98 15.36,64.98 16.1,64.24 TL2.1
ME_FWP: length 76
  TOP w0.102: v2(95.12,44.68) 94.81,44.98 v1(94.81,45.66) 94.81,47.61 94.27,48.15 94.27,48.25 94.27,48.26 RC126.1 ; v2(53.76,67.75) 52.79,67.75 52.31,68.23 RE19.1 50.68,68.35 50.33,68.7 50.33,69.02 50.11,69.23 UE1.80
  IN1 w0.127: v2(53.76,67.75) 53.76,67.72 53.41,67.37 53.41,65.43 54.08,64.76 54.08,59.17 55.22,58.03 55.22,46.62 56.03,45.81 56.03,44.82 57.42,43.43 58.08,43.43 60.11,41.4 67.37,41.4 67.63,41.14 88.61,41.14 91.72,44.26 93.45,44.26 93.87,44.68 v2(95.12,44.68)
MEC_XTAL1: length 2.5
  TOP w0.102: YE1.1 37.72,82.28 CE3.1 RE47.2
MEC_XTAL1_R: length 2.7
  TOP w0.102: RE47.1 36.83,78.75 37.2,78.38 UE1.123
MEC_XTAL2: length 5.5
  TOP w0.102: UE1.125 36.4,78.03 35.96,78.48 v1(35.96,78.84) RE45.1 CE4.1 35.96,81.23 35.26,81.92 YE1.2
MEM_SMBCLK: length 11.1
  TOP w0.102: v2(130.12,56.84) 130.29,56.67 130.29,55.41 129.31,54.43 QC1.6
  IN2 w0.127: v2(130.12,56.84) 130.31,57.03 130.31,57.74 129.8,58.26 129.8,61.1 129.39,61.51 129.39,62.52 v2(129.21,62.7)
  BOTTOM w0.102: UC1.R7 128.84,62.7 v2(129.21,62.7) ; v2(130.12,56.84) 130.32,56.64 130.32,56.44 130.19,56.3 RPC3.1
MEM_SMBDATA: length 10.5
  TOP w0.102: v2(130.71,56.84) 130.52,56.65 130.52,55.81 130.6,55.73 QC1.3
  IN2 w0.127: v2(130.71,56.84) 130.57,56.98 130.57,57.85 130.05,58.36 130.05,61.21 129.64,61.61 129.64,62.88 v2(129.21,63.31)
  BOTTOM w0.102: UC1.R8 128.88,63.31 v2(129.21,63.31) ; v2(130.71,56.84) 130.57,56.7 130.57,56.41 130.69,56.28 RPC3.2
MIC_CAP: length 10.6
  TOP w0.203: CA26.1 24.74,23.17 24.93,22.98 v1(25.89,22.98) 26.83,22.98 27.85,21.97 27.85,18.98 29.58,17.25 UA1.19
MODEL_ID: length 5
  TOP w0.102: UE1.109 42.8,78.29 43.01,78.49 v1(43.01,78.75) 43.24,78.75 CE1.1 ; RE3.2 45.04,79.69 CE1.1 ; CE1.1 RE4.2
MSCLK: length 7
  TOP w0.102: RE55.2 43.5,92.5 JDEG1.6 43.5,94.96 42.98,95.49 v1(39.68,95.49)
MSDATA: length 6.5
  TOP w0.102: v1(42.76,88.63) 42.76,88.76 42.15,89.36 RE56.2 42.65,90.38 42.65,91.7 42.23,92.12 RE62.1 43,92.95 JDEG1.7
NB_MUTE#: length 19.5
  TOP w0.102: UE1.119 38.8,75.97 39.36,75.41 40.5,75.41 40.98,74.93 43.08,74.93 v2(43.5,74.52) ; v1(46.69,84.51) 46.69,84.26 46.41,83.98 v2(46.41,83.52) 45.65,83.52 RE28.1
  IN1 w0.127: v2(46.41,83.52) 45.79,83.52 43.5,81.23 43.5,77.88 43.11,77.5 43.11,74.9 v2(43.5,74.52)
NCT7718_DXN: length 77.9
  IN2 w0.254: v2(148.31,125.22) 149.2,125.22 149.64,125.66 149.64,138.11 148.43,139.31 140.31,139.31 131.86,130.87 131.86,128.41 v2(131.94,128.33)
  BOTTOM w0.254: v2(148.31,125.22) 148.69,125.6 C22.2 150.02,125.6 150.29,125.87 Q14.3 ; C23.2 102.37,125.13 U2.3 104.07,125.13 104.17,125.03 104.83,125.03 105.7,124.16 105.7,122.89 105.97,122.61 113.57,122.61 120.62,129.66 v1(122.72,129.66) 131.42,129.66 131.94,129.14 v2(131.94,128.33)
NCT7718_DXP: length 82
  IN2 w0.254: v2(148.31,124.58) 149.28,124.58 150.15,125.45 150.15,138.32 148.64,139.82 140.09,139.82 131.35,131.08 v2(131.35,128.33)
  BOTTOM w0.254: Q14.1 152.19,123.93 Q14.2 150.1,123.93 149.83,124.2 C22.1 148.69,124.2 v2(148.31,124.58) ; C23.1 101.92,124.67 102.44,124.67 102.63,124.48 U2.2 104,124.48 104.04,124.52 104.62,124.52 105.19,123.95 105.19,122.68 105.76,122.11 113.78,122.11 120.83,129.15 v1(124.56,129.15) 131.21,129.15 131.43,128.93 131.43,128.41 v2(131.35,128.33)
NRB_BIT: length 12
  IN1 w0.127: v2(110.17,59.51) 110.2,59.48 111.55,59.48 111.73,59.3 113.09,59.3 114.82,61.04 116.89,61.04 117.7,61.84 117.7,63.24 117.97,63.51 v2(117.97,63.66)
  BOTTOM w0.076: v2(117.97,63.66) 118.33,63.29 UC1.AR7
  BOTTOM w0.102: RC44.2 109.79,59.97 110.17,59.6 v2(110.17,59.51)
ONE_DIMM#: length 27
  TOP w0.102: RC181.2 121.73,41.7 RC182.1 120.94,42.81 120.52,43.22 120.52,43.28 120.1,43.71 120.1,49.53 115.6,54.03 115.6,58.69 117.34,60.44 117.34,61.35 117.76,61.77 118.09,61.77 118.13,61.81 118.14,61.81 118.8,62.48 118.8,63.18 v1(118.99,63.37) 119.31,63.69 v2(119.31,63.72)
  BOTTOM w0.076: UC1.AP7 v1(118.98,63.37) 119.31,63.69 v2(119.31,63.72)
PANEL_BKEN_EC: length 232.1
  TOP w0.102: UE1.117 39.6,78.3 v2(39.82,78.51) ; RP2.8 v2(217.2,51.4)
  IN1 w0.127: v2(39.82,78.51) 39.82,77.69 39.37,77.24 39.37,65.03 41.21,63.19 41.21,61.94 42.39,60.76 42.39,55.36 46.13,51.62 46.13,45.22 56.46,34.9 60.47,34.9 62.35,33.01 91.42,33.01 92.5,34.1 101.45,34.1 102.44,33.11 144.26,33.11 146.37,31 152.92,31 153.75,31.83 162.14,31.83 162.73,31.24 179.54,31.24 181.22,32.92 192.63,32.92 193.89,34.18 206.08,34.18 208.67,36.78 208.67,38.36 210.57,40.26 215.08,40.26 217.83,43.01 217.83,50.78 v2(217.2,51.4)
PBAT_CHG_SMBCLK: length 245
  TOP w0.102: v2(35.09,72.31) 34.88,72.52 34.7,72.52 34.62,72.43 UE1.9 32.69,72.43 32.04,73.08 29.17,73.08 RE9.1 ; PR42.2 160.56,36.94 PD5.3 161.51,37.72 161.73,37.5 161.73,37.17 v2(161.58,37.02)
  IN2 w0.127: v2(46.64,25.78) 46.48,25.62 46.48,25.22 47.21,24.49 87.78,24.49 88.44,25.15 101.01,25.15 101.3,25.44 113.5,25.44 114.25,26.19 118.88,26.19 119.43,25.64 127,25.64 127.44,26.07 134.61,26.07 139.9,31.36 152.55,31.36 153.78,32.6 157.77,32.6 161.74,36.57 161.74,36.85 v2(161.58,37.02) 161.71,37.14 161.71,37.57 162.04,37.9 162.72,37.9 164.12,36.51 174.81,36.51 175.14,36.84 192.89,36.84 194.78,38.73 200.46,38.73 205.99,44.26 205.99,47.28 205.52,47.75 205.52,49.27 206.09,49.84 206.09,51.32 v2(205.91,51.49)
  BOTTOM w0.102: v2(35.09,72.31) 34.91,72.49 34.76,72.49 33.17,70.91 33.17,50.15 45.27,38.05 46.12,38.05 47.74,36.43 47.74,34.47 47.98,34.23 47.98,31.2 46.47,29.69 46.47,25.95 v2(46.64,25.78) ; PRB18.1 205.3,51.84 205.65,51.84 205.78,51.96 205.94,51.96 206.09,51.81 206.09,51.67 v2(205.91,51.49)
PBAT_CHG_SMBDAT: length 243.4
  TOP w0.102: PR37.2 162.45,37.72 PD5.2 162.09,37.72 161.96,37.59 161.96,37.22 v2(162.16,37.02) ; v2(35.09,72.89) 34.94,72.75 34.7,72.75 34.62,72.83 UE1.8 32.67,72.83 31.82,73.69 RE8.1
  IN2 w0.127: v2(46.05,25.79) 46.22,25.62 46.22,25.12 47.1,24.24 87.89,24.24 88.55,24.9 101.11,24.9 101.41,25.19 113.61,25.19 114.35,25.93 118.77,25.93 119.32,25.38 127.11,25.38 127.54,25.81 134.71,25.81 140.01,31.11 152.65,31.11 153.89,32.34 157.87,32.34 162,36.47 162,36.85 v2(162.16,37.02) 161.96,37.22 161.96,37.46 162.15,37.65 162.62,37.65 164.01,36.25 174.91,36.25 175.24,36.58 193,36.58 194.89,38.48 200.57,38.48 206.24,44.15 206.24,47.38 205.77,47.85 205.77,49.17 206.35,49.74 206.35,51.34 v2(206.5,51.49)
  BOTTOM w0.102: v2(35.09,72.89) 34.91,72.72 34.66,72.72 32.95,71 32.95,50.06 45.18,37.82 46.02,37.82 47.51,36.34 47.51,34.37 47.75,34.13 47.75,31.29 46.24,29.78 46.24,25.97 v2(46.05,25.79) ; PRB17.1 205.28,52.07 205.55,52.07 205.68,52.19 206.04,52.19 206.32,51.91 206.32,51.67 v2(206.5,51.49)
PBAT_PRES#: length 232.9
  TOP w0.102: v2(35.02,64.26) 34.85,64.43 UE1.29 32.72,64.43 32.28,63.99 32.28,62.84 CE16.1 31.1,60.79 PC14.1
  TOP w0.254: v2(200.97,32.23) 200.97,44.86 v2(200.95,44.89) 200.94,44.9 PRB42.1 PCB31.1 ; v2(164.44,28.93) 164.88,29.37 v1(164.88,34.65) PR39.2 PR41.1 165.78,36.95 PD6.2
  IN1 w0.127: v2(35.02,64.26) 34.64,64.26 33.23,62.84 33.23,56.82 37.33,52.71 37.33,41.93 44.68,34.59 49.37,34.59 54.41,29.55 56.96,29.55 58.84,27.67 93.65,27.67 94.94,28.96 95.57,28.96 96.07,28.46 99.71,28.46 100.8,29.55 107.31,29.55 109.48,27.38 113.28,27.38 114.69,28.79 129.47,28.79 130.56,29.88 135.76,29.88 136.96,31.08 143.27,31.08 146.27,28.08 158.01,28.08 158.7,28.76 164.27,28.76 v2(164.44,28.93) 179.95,28.93 182.16,31.14 199.89,31.14 v2(200.97,32.23)
  BOTTOM w0.254: v2(200.95,44.89) 200.95,45.42 PRB40.1
PCH_BATLOW#: length 24.4
  TOP w0.102: RC89.1 102.14,54.77 v1(102.29,54.92) 102.53,55.16 v2(102.53,55.49)
  IN1 w0.127: v2(116.68,67.18) 115.48,65.97 115.48,63.8 113.83,62.16 112.98,62.16 111.68,60.86 110.18,60.86 108.24,58.92 107.52,58.92 106.78,58.18 106.78,56.21 105.96,55.39 105.46,55.39 104.83,56.02 103.06,56.02 v2(102.53,55.49)
  BOTTOM w0.076: v2(116.68,67.18) 117.03,66.83 UC1.AU13
PCH_DPWROK: length 8
  TOP w0.102: v2(108.64,70.16) v4(106.31,70.16)
  BOTTOM w0.076: UC1.BB20 112.95,70.56 112.75,70.37 RC97.2 111.04,70.37 110.96,70.29 RC87.1 110.27,69.83 108.98,69.83 v2(108.64,70.16)
PCH_ESPI_CLK: length 7.4
  BOTTOM w0.076: UC1.AW9 115.61,64.24 113.79,64.24
  BOTTOM w0.102: RC15.1 111.32,61.76 113.79,64.24
PCH_ESPI_IO0: length 6.1
  BOTTOM w0.076: 112.87,67.24 113.53,67.24 113.64,67.34 114.07,67.34 114.38,67.22 114.91,67.22 UC1.AY13
  BOTTOM w0.102: RPC2.1 110.57,65.48 112.31,67.22 v1(112.47,67.22) 112.49,67.24 112.87,67.24
PCH_ESPI_IO1: length 5.5
  BOTTOM w0.076: 113.26,67.06 113.27,67.08 113.62,67.08 113.72,67.18 114,67.18 114.56,66.92 UC1.BA13
  BOTTOM w0.102: 113.26,67.06 112.96,67.06 112.95,67.05 112.73,67.05 111.9,66.22 111.74,66.22 v1(111.68,66.16) 110.5,64.98 RPC2.2
PCH_ESPI_IO2: length 5
  BOTTOM w0.102: RPC2.3 110.65,64.48 110.87,64.7 110.87,64.92 112.81,66.86 113.87,66.86 UC1.BB13
PCH_ESPI_IO3: length 6.9
  BOTTOM w0.076: 112.31,66.09 112.83,66.61 114.71,66.61 114.72,66.62 115.06,66.62 115.07,66.62 115.35,66.34 UC1.AY12
  BOTTOM w0.102: RPC2.4 110.6,63.98 111.06,64.45 111.06,64.84 112.31,66.09
PCH_JTAG_TCK1: length 6.1
  BOTTOM w0.076: UC1.B56 136.1,91.71 136.32,91.71 136.44,91.77 136.7,91.77 136.89,91.58 137.72,91.58 137.82,91.68
  BOTTOM w0.102: 137.82,91.68 138.7,91.68 138.79,91.78 TPC3.1 139.45,91.78 139.56,91.68 140.69,91.68 RC147.1
PCH_PCIE_WAKE#: length 38.6
  BOTTOM w0.076: UC1.BB15 113.81,68.25 108.1,68.25 103.99,64.13
  BOTTOM w0.102: 103.99,64.13 103.99,64.01 98.5,58.52 98.5,57.56 98.08,57.15 98.08,52.51 98.55,52.04 98.55,50.13 98.29,49.87 98.29,42.97 98.46,42.79 RC99.2 98.52,42.36 98.79,42.1 98.79,41.92 98.99,41.71 v1(98.99,40.32)
PCH_PLTRST#: length 84.9
  TOP w0.102: v2(154.31,30.77) 154.36,30.72 154.36,29.35 154.14,29.12 153.6,29.12 153.55,29.17 UM2.2
  IN1 w0.127: v2(130.5,43.4) 129.29,43.4 128.62,42.73 120.56,42.73 119.89,43.4 118.88,43.4 v2(118.72,43.56)
  IN2 w0.127: v2(124.81,65.45) 125.96,65.45 126.59,64.82 126.59,63.55 126.4,63.36 126.4,61.78 126.14,61.53 126.14,60.12 122.97,56.95 122.97,54.22 120.88,52.13 120.88,48.23 120.08,47.43 120.08,44.92 v2(118.72,43.56)
  BOTTOM w0.102: UC4.1 120.37,44 120.21,43.84 119.86,43.84 119.72,43.99 ; UC4.2 119.72,43.99 ; 119.72,43.99 119.35,43.62 118.78,43.62 v2(118.72,43.56) 118.53,43.56 117.88,44.2 RC108.1 ; v2(124.81,65.45) 124.64,65.28 124.18,65.28 123.47,64.56 121.14,64.56 120.42,65.29 119.93,65.29 119.64,65 UC1.AN10 ; v2(154.31,30.77) 148.18,30.77 144.83,34.12 144.83,34.41 144.38,34.86 143.95,34.86 143.44,34.35 135.82,34.35 134.36,35.81 v1(134.36,36.58) 134.36,38.96 131.21,42.11 131.21,42.86 130.67,43.4 v2(130.5,43.4)
PCH_POPIRCOMP: length 15.1
  TOP w0.305: v2(116.71,69.07) 116.29,69.07 114.99,67.77 114.99,66.05 112.07,63.13 v1(111.46,63.13) 108.6,63.13 107.31,61.84 RC120.1
  BOTTOM w0.254: v2(116.71,69.07) 116.71,68.98 UC1.AU16
PCH_RSMRST#: length 110.5
  TOP w0.102: v2(97.06,36.3) 96.91,36.45 96.91,45.3 97.73,46.11 97.73,46.32 v2(99.48,48.06) ; v2(45.31,66.04) 44.36,66.04 43.82,65.49 34.8,65.49 34.54,65.23 UE1.27 32.69,65.23 31.82,64.36 31.82,63.56 31.7,63.43 RE20.1 ; v2(98.76,53.14) UC5.1
  IN1 w0.127: v2(49.13,53.27) 49.44,52.97 49.44,48.42 49.88,47.98 49.88,45.34 58.17,37.05 61.54,37.05 61.91,36.68 87.12,36.68 87.86,35.94 96.74,35.94 97.06,36.25 v2(97.06,36.3)
  BOTTOM w0.102: v2(45.31,66.04) 46.14,65.21 46.14,64.9 46.24,64.8 46.24,61.04 48.52,58.76 48.52,54.32 48.78,54.07 48.78,53.63 v2(49.13,53.27) ; v2(99.48,48.06) 98.97,48.06 98.75,48.28 98.75,49.68 99.01,49.94 99.01,52.23 98.76,52.47 v2(98.76,53.14)
PCH_RSMRST#_Q: length 49.4
  TOP w0.102: v2(101.72,57.34) 101.72,57.48 101.09,58.11 v1(101.09,58.71) 101.09,59.05 100.85,59.29 RC148.1 100.06,59.28 RC94.2 100.06,58.35 UC5.4
  IN2 w0.127: v2(101.72,57.34) 100.81,56.42 100.81,54.35 99.16,52.7 98.06,52.7 95.97,50.6 95.22,50.6 v2(95.2,50.63)
  BOTTOM w0.102: v2(95.2,50.63) 95.22,50.66 95.22,52.01 96.49,53.28 96.49,60.14 99.21,62.86 99.21,62.87 106.5,70.16 108.06,70.16 108.57,69.65 111.4,69.65 RC97.1 113.55,69.45 113.7,69.6 114.95,69.6 UC1.AY17
PCH_RTCRST#: length 58.6
  IN2 w0.127: v2(91.79,48.64) 92.95,48.64 93.87,49.56 95.64,49.56 98.27,52.19 99.37,52.19 101.32,54.14 101.32,54.96 102.27,55.91 102.27,57.97 103.06,58.76 104.02,58.76 104.62,59.37 106.88,59.37 107.18,59.07 108.03,59.07 109.59,60.63 110.32,60.63 111.78,62.09 111.78,62.5 115.35,66.07 115.64,66.07 116.21,66.64 116.21,67.4 116.51,67.71 118.38,67.71 118.41,67.73 119.41,67.73 v2(119.9,68.22)
  BOTTOM w0.102: UC1.AM16 120.21,68.64 v2(119.9,68.22) ; JCMOS1.1 90.72,49.7 v2(91.79,48.64) 91.79,48.33 90.01,46.55 90.01,41.22 92.49,38.74 RC78.1 93.07,37.98 93.07,36.76 CC5.1 91.45,36.25 QC2.1
PCH_RTCX1: length 25
  TOP w0.102: v2(107.6,60.09) 107.6,60.03 v1(107.09,59.52) 107,59.43 105.14,59.43 RC82.2 104.95,59.56 CC8.1 104.78,58.52 104.78,57.43 105.09,57.11 YC2.1
  IN2 w0.076: 116.04,69.07 116.4,69.44 119.66,69.44 119.71,69.49 120.07,69.49 v2(120.55,69.97)
  IN2 w0.127: v2(107.6,60.09) 107.61,60.09 109.17,61.65 109.84,61.65 110.32,61.65 114.56,65.89 114.56,67.59 116.04,69.07
  BOTTOM w0.102: UC1.AM18 120.29,69.71 v2(120.55,69.97)
PCH_RTCX2: length 26.7
  TOP w0.102: v2(107.6,60.67) 107.56,60.67 106.8,59.91 105.72,59.91 105.59,60.05 104.47,60.05 104.07,59.64 RC82.1 104.07,58.73 CC9.1 104.24,58.55 104.24,57.34 104.02,57.11 YC2.2
  IN2 w0.076: v2(119.9,69.99) 119.56,69.64 116.58,69.64 116.55,69.67
  IN2 w0.127: 116.55,69.67 116.2,69.67 114.24,67.72 114.24,65.88 110.52,62.16 107.65,62.16 107.06,61.56 107.06,61.22 v2(107.6,60.67)
  BOTTOM w0.102: UC1.AM20 120.29,70.37 v2(119.9,69.99)
PCH_SMBCLK: length 221.8
  TOP w0.102: RC28.2 131.19,54.31 QC1.1 130.49,54.43 130.41,54.34 v2(129.82,54.34) ; JVGA.12 217.11,33.25 216.98,33.38 216.65,33.38 216.09,32.82 215.38,32.82 215.2,32.65 215.2,32.2 v2(215.36,32.03) ; v2(193.14,39.81) v1(191.96,39.81) 191.8,39.81 190.84,40.77 US1.1
  IN1 w0.127: v2(159.74,38.44) 159.58,38.6 159.01,38.6 158.82,38.8 155.43,38.8 151.76,42.48 148.19,42.48 147.61,43.06 134.54,43.06 133.43,41.96 130.65,41.96 128.88,40.19 128.02,40.19 127.8,40.42 127.3,40.42 127.14,40.26 127.14,40.17 v2(127.31,40)
  IN2 w0.127: v2(193.14,39.81) 192.95,40 184.19,40 182.23,38.04 173.91,38.04 172.94,37.08 164.31,37.08 162.59,38.79 160.98,38.79 160.79,38.6 159.91,38.6 v2(159.74,38.44) ; v2(92.81,39.36) 92.97,39.2 92.97,38.95 93.23,38.69 95.03,38.69 95.36,39.02 100.33,39.02 100.67,38.69 105,38.69 105.41,39.1 110.47,39.1 110.88,38.69 123.88,38.69 124.43,39.24 126.91,39.24 127.14,39.48 127.14,39.84 v2(127.31,40) 127.14,40.17 127.14,42.81 126.93,43.03 126.93,49.8 128.22,51.09 128.22,53.31 129.04,54.14 129.04,54.58 129.06,54.59 129.17,54.72 129.38,54.74 v2(129.82,54.34) ; v2(77.6,44.75) 77.44,44.59 77.44,44.42 77.62,44.24 78.48,44.24 78.89,44.65 81.86,44.65 82.27,44.24 82.97,44.24 83.03,44.3 83.03,44.48 v2(82.85,44.66) 83.02,44.82 83.02,45.03 83.3,45.31 83.81,45.31 83.83,45.33 89.11,45.33 90.19,46.41 90.55,46.41 v2(90.95,46.81)
  BOTTOM w0.102: v2(82.85,44.66) 83.03,44.48 83.03,43.37 82.58,42.92 67.28,42.92 64.8,45.4 63.31,45.4 62.68,46.03 62.68,46.85 63.32,47.49 65.12,47.49 65.38,47.24 JDIMM2.253 ; v2(215.36,32.03) 215.2,31.87 215.2,31.59 214.85,31.25 212.49,31.25 212.23,31.5 210.04,31.5 209.19,30.65 200.91,30.65 193.71,37.85 193.71,40.8 193.58,40.93 193.24,40.93 193.14,40.83 v2(193.14,39.81) ; v2(92.81,39.36) 92.94,39.49 92.94,39.8 91.09,41.65 91.09,46.67 v2(90.95,46.81) ; v2(77.6,44.75) 77.45,44.91 77.45,45.78 76.38,46.85 76.38,47 76.62,47.24 JDIMM1.253
PCH_SMBDATA: length 225
  TOP w0.102: v2(214.78,32.03) 214.97,32.22 214.97,32.74 215.28,33.05 215.99,33.05 216.55,33.61 216.98,33.61 217.11,33.75 JVGA.11 ; QC1.4 128.74,55.73 v2(128.5,55.49) 128.07,55.49 RC27.2 ; v2(193.14,42.27) v1(191.88,42.27) US1.4
  IN1 w0.127: v2(126.73,40) 126.89,40.17 126.89,40.36 127.2,40.67 127.9,40.67 128.13,40.44 128.78,40.44 130.54,42.21 133.33,42.21 134.43,43.32 147.71,43.32 148.3,42.73 151.86,42.73 155.54,39.05 158.92,39.05 159.12,38.86 159.58,38.86 v2(159.74,39.02)
  IN2 w0.127: v2(128.5,55.49) 128.97,55.07 128.98,54.89 128.98,54.89 128.86,54.76 128.79,54.68 128.79,54.24 127.96,53.42 127.96,51.19 126.67,49.91 126.67,42.92 126.89,42.71 126.89,40.17 v2(126.73,40) 126.89,39.84 126.89,39.58 126.8,39.49 124.32,39.49 123.78,38.95 110.98,38.95 110.58,39.35 105.31,39.35 104.9,38.95 100.77,38.95 100.44,39.28 95.26,39.28 94.93,38.95 93.33,38.95 93.23,39.05 93.23,39.2 v2(93.39,39.36) ; v2(159.74,39.02) 159.91,38.86 160.69,38.86 160.88,39.05 162.7,39.05 164.41,37.33 172.84,37.33 173.8,38.3 182.13,38.3 184.08,40.25 191.12,40.25 v2(193.14,42.27) ; v2(91.53,46.81) 91.53,46.81 90.88,46.16 90.3,46.16 89.21,45.08 83.94,45.08 v2(83.48,44.62) 83.28,44.42 83.28,44.2 83.07,43.99 82.16,43.99 81.75,44.39 78.99,44.39 78.58,43.99 77.52,43.99 77.19,44.32 77.19,44.57 v2(77.01,44.75)
  BOTTOM w0.102: v2(93.39,39.36) 93.17,39.59 93.17,39.9 91.32,41.74 91.32,46.61 v2(91.53,46.81) ; v2(193.14,42.27) 193.14,41.26 193.24,41.16 193.68,41.16 193.94,40.9 193.94,37.95 201,30.88 209.1,30.88 209.95,31.73 212.33,31.73 212.58,31.48 214.76,31.48 214.97,31.69 214.97,31.84 v2(214.78,32.03) ; JDIMM2.254 62.2,46.99 62.45,46.74 62.45,45.93 63.21,45.17 64.71,45.17 67.19,42.69 82.67,42.69 83.26,43.28 83.26,44.48 83.39,44.62 v2(83.48,44.62) ; v2(77.01,44.75) 77.22,44.96 77.22,45.69 75.91,47 70.96,47 JDIMM1.254
PCH_SPI_CLK: length 39.7
  IN2 w0.127: v2(118.45,49.72) 118.54,49.8 118.54,51.79 118.91,52.17 120.27,52.17 120.37,52.06 120.37,51.69 120.25,51.56 119.41,51.56 119.29,51.44 119.29,51.18 119.41,51.06 120.25,51.06 120.37,50.93 120.37,50.68 120.25,50.55 119.59,50.55 119.41,50.37 119.41,50.2 119.58,50.04 120.25,50.04 120.37,49.91 120.37,49.15 119.03,47.8 119.03,45.28 118.11,44.37 118.11,42.27 v2(118.21,42.18)
  BOTTOM w0.076: 115.5,58.48 115.5,58.78 116.12,59.41 116.12,59.84 116.43,60.14 UC1.AV2
  BOTTOM w0.102: v2(118.45,49.72) 118.5,49.66 118.5,49.37 v1(118.34,49.2) 117.83,48.69 117.65,48.69 117.39,48.95 117.4,48.99 117.4,49.6 118.02,50.22 118.02,50.54 117.85,50.71 117.71,50.71 117.56,50.57 117.42,50.57 117.28,50.71 117.28,50.85 117.42,51 117.42,51.14 116.21,52.35 116.21,53.02 116.08,53.14 115.24,53.14 115.11,53.27 115.11,53.64 115.22,53.74 116.14,53.74 116.25,53.84 116.25,54.04 116.14,54.15 115.6,54.15 115.5,54.25 115.5,58.48 ; RC178.2 119.83,43.11 119.03,43.11 118.84,42.92 RC21.2 118.54,42.51 v2(118.21,42.18) 117.69,41.66 RX3.1
PCH_SPI_CLK_R: length 3.2
  TOP w0.102: v4(120.51,44.28) 120.84,43.95 v2(120.96,43.95)
  BOTTOM w0.102: v2(120.96,43.95) 120.86,43.84 RC178.1 121.32,42.77 UC3.6
PCH_SPI_CLK_TPM: length 1.5
  BOTTOM w0.102: RX3.2 116.63,41.71 115.6,41.71 115.56,41.67 UX1.19
PCH_SPI_CS#0: length 28.8
  TOP w0.102: v2(127.85,44.42) 127.86,44.42 v4(128.28,44.84)
  BOTTOM w0.076: RC18.2 115.99,56.4 115.99,57.33 116.37,57.71 116.37,58.99 116.7,59.32 116.7,60.31 117.12,60.73 UC1.AU3
  BOTTOM w0.102: RC18.2 116.73,55.65 116.73,52.51 118.55,50.69 118.55,50.33 118.99,49.89 118.99,49.37 119.22,49.14 120.25,49.14 121.76,47.63 123.46,47.63 123.7,47.38 126.67,47.38 127,47.05 127,44.65 127.24,44.42 v2(127.85,44.42) 128.56,44.42 128.69,44.54 128.69,45.14 128.85,45.31 UC3.1
PCH_SPI_CS#2: length 25.6
  IN2 w0.127: v2(119.39,49.59) 118.28,48.48 118.28,47.21 117.53,46.45 117.53,46.24 117.65,46.12 118.27,46.12 118.4,45.99 118.4,45.73 118.27,45.61 117.65,45.61 117.53,45.48 117.53,44.65 117.29,44.42 117.29,44.17 117.42,44.04 117.48,44.04 117.6,43.91 117.6,43.66 117.48,43.53 117.42,43.53 117.29,43.4 117.29,43.15 117.42,43.02 117.48,43.02 117.6,42.9 117.6,42.64 117.11,42.15 117.11,41.84 117.41,41.54 117.41,41.36 116.75,40.7 116.62,40.7 v2(116.02,41.3)
  BOTTOM w0.076: 116.54,56.71 116.54,58.84 117.12,59.43 UC1.AU1
  BOTTOM w0.102: 116.54,56.71 116.96,56.29 116.96,52.61 119.01,50.56 119.01,50.38 v1(119.25,50.14) 119.39,50 v2(119.39,49.59) ; UX1.20 115.89,41.17 v2(116.02,41.3)
PCH_SPI_D0: length 46.4
  IN2 w0.127: v2(104.99,40.25) 105.17,40.07 114.69,40.07 115.21,39.55 116.13,39.55 117.99,41.41 118.13,41.41 v2(118.85,42.13)
  BOTTOM w0.076: 113.24,57.69 114.74,59.19 114.74,59.9 114.84,60 114.84,60.28 115.13,60.57 115.35,60.57 115.55,60.77 115.55,60.96 115.8,61.22 UC1.AV3
  BOTTOM w0.102: v2(104.99,40.25) 104.64,40.6 104.64,43.02 104.97,43.35 104.97,46.38 106.51,47.93 107.01,47.93 108.3,49.22 108.3,51.56 109.28,52.54 109.28,54.72 110.21,55.65 110.21,56.19 110.28,56.27 RC40.2 110.71,56.83 111.58,57.69 113.24,57.69 ; RC179.2 v2(118.85,42.13) 118.42,41.7 118.42,41.47 RX2.1
PCH_SPI_D0_R: length 6.3
  TOP w0.102: v2(123.43,43.44) 122.79,43.44 v4(122.39,43.04)
  BOTTOM w0.102: v2(123.43,43.44) 123.76,43.11 123.76,41.84 123.41,41.5 UC3.5 121.49,41.5 RC179.1
PCH_SPI_D0_TPM: length 1.5
  BOTTOM w0.102: UX1.21 116.57,40.67 RX2.2
PCH_SPI_D1: length 48.8
  IN2 w0.127: v2(120.97,47.65) 120.5,47.18 120.5,41.37 v2(118.49,39.36)
  BOTTOM w0.076: 115.13,58.65 115.96,59.48 115.96,59.9 116.14,60.08 116.14,60.91 116.07,60.97 115.97,60.97 UC1.AW3
  BOTTOM w0.102: RC180.2 125.2,47.16 123.5,47.16 123.26,47.4 121.22,47.4 v2(120.97,47.65) 120.91,47.65 119.67,48.88 118.7,48.88 117,47.18 117,47.18 114.91,45.09 111.29,45.09 108.76,47.62 108.76,51.2 111.32,53.75 113.99,53.75 114.99,54.76 114.99,55.08 v1(115.1,55.18) 115.13,55.22 115.13,58.65 ; v2(118.49,39.36) 118.63,39.23 RX1.1
PCH_SPI_D1_R: length 6.3
  TOP w0.102: v2(127.39,44.01) 127.39,43.47 v4(127.31,43.39)
  BOTTOM w0.102: RC180.1 126.57,44.46 127.03,44.01 v2(127.39,44.01) 129.72,44.01 UC3.2
PCH_SPI_D1_TPM: length 2.7
  BOTTOM w0.102: RX1.2 v1(116.54,38.64) 116.37,38.64 115.84,39.17 UX1.24
PCH_SPI_D2: length 38.5
  BOTTOM w0.076: 115.35,59.43 115.35,59.95 115.48,60.08 115.48,60.41 115.58,60.51 115.79,60.51 115.87,60.43 UC1.AW2
  BOTTOM w0.102: RC176.1 123.57,46.7 123.1,47.17 120.82,47.17 v1(120.06,47.93) 118.07,47.93 117.51,47.37 117.51,47.36 115.01,44.86 111.2,44.86 108.53,47.52 108.53,51.29 111.23,53.98 113.84,53.98 114.74,54.88 114.74,56.44 114.6,56.57 114.33,56.57 114.14,56.38 RC41.2 114.1,56.29 RC19.2 113.36,57.44 115.35,59.43
PCH_SPI_D2_R: length 8.4
  TOP w0.102: v4(124.8,44) 125.31,44 v2(125.47,44.17)
  BOTTOM w0.102: UC3.3 126.87,42.77 v2(125.47,44.17) 125.47,46.02 RC176.2
PCH_SPI_D3: length 45.8
  IN2 w0.127: v2(118.84,41.45) 118.54,41.16 118.1,41.16 116.23,39.29 115.1,39.29 114.58,39.82 105.15,39.82 v2(105,39.66)
  BOTTOM w0.076: 113.45,60.01 113.79,60.36 113.99,60.36 114.24,60.62 114.24,61.07 114.38,61.2 114.84,61.2 114.96,61.32 115.31,61.32 115.73,61.75 116.65,61.75 116.86,61.54 UC1.AU4
  BOTTOM w0.102: 113.45,60.01 113.45,59.87 112.63,59.05 112.37,59.05 109.77,56.46 RC20.2 109.05,55.28 109.05,52.63 108.08,51.65 108.08,49.32 106.91,48.15 106.4,48.15 104.71,46.46 104.71,43.42 104.41,43.12 104.41,40.25 v2(105,39.66) ; v2(118.84,41.45) 119.08,41.45 119.36,41.17 RC177.1
PCH_SPI_D3_R: length 8.6
  TOP w0.102: v2(123.73,44.04) 123.34,44.04 122.79,44.59 v4(122.79,44.74)
  BOTTOM w0.102: UC3.7 v2(123.73,44.04) 123.86,44.04 123.99,43.91 123.99,41.74 123.2,40.95 121.45,40.95 121.22,41.17 RC177.2
PCIE_CRX_C_LANTX_N5: length 4.3
  TOP w0.097: UL1.18 25.48,88.12 25.54,88.17 25.54,88.56 25.9,88.93 26.92,88.93 27.03,88.82 v3(27.62,88.82) 28.5,88.82 CL2.2
PCIE_CRX_C_LANTX_P5: length 4.2
  TOP w0.097: CL1.2 28.66,88.18 28.25,88.59 26.99,88.59 26.88,88.7 v3(26.35,88.7) 25.94,88.7 25.72,88.49 25.72,88.24 25.88,88.08 UL1.17
PCIE_CRX_LANTX_N5: length 172.6
  TOP w0.097: v2(30.63,88.83) 30.38,88.58 29.98,88.58 CL2.1
  IN2 w0.076: v2(133.47,69.11) 133.68,68.91 133.68,68.8 133.57,68.7 132.97,68.7 132.36,69.3 131.83,69.3 130.69,70.45 130.69,75.31 131.18,75.8 131.18,77.25 131.69,77.76 131.69,95.95 131.71,95.97
  IN2 w0.122: 131.71,95.97 131.73,95.98 131.73,96.01 131.73,96.01 131.73,99.06 130.84,99.94 129.05,99.94 128.3,100.69 128.3,107.52 117.39,118.43 109.7,118.43 109.27,118 100.57,118 99.95,118.62 86.2,118.62 85.19,119.62 73.64,119.62 73.07,120.19 65.69,120.19 65.12,119.62 44.91,119.62 31.73,106.45 31.73,89.23 31.07,88.57 30.89,88.57 v2(30.63,88.83)
  BOTTOM w0.097: v2(133.47,69.11) UC1.F16
PCIE_CRX_LANTX_P5: length 172.7
  TOP w0.097: CL1.1 29.87,88.39 30.49,88.39 v2(30.63,88.24)
  IN2 w0.076: v2(134.08,69.11) 133.88,68.91 133.88,68.72 133.65,68.49 132.89,68.49 132.28,69.1 131.74,69.1 130.48,70.36 130.48,75.39 130.98,75.89 130.98,77.28 131.52,77.83 131.52,95.96 131.48,96.01 131.48,96.02
  IN2 w0.122: v2(30.63,88.24) 30.72,88.32 31.17,88.32 31.98,89.13 31.98,106.35 45.01,119.38 65.22,119.38 65.79,119.94 72.96,119.94 73.53,119.38 85.09,119.38 86.1,118.37 99.84,118.37 100.46,117.75 109.37,117.75 109.81,118.18 117.29,118.18 128.05,107.42 128.05,100.59 128.94,99.7 130.74,99.7 131.48,98.95 131.48,96.02
  BOTTOM w0.097: v2(134.08,69.11) UC1.E16
PCIE_CRX_NVMETX_N9: length 151.6
  IN2 w0.076: v2(133.5,72.77) 133.64,72.77 133.82,72.58 133.82,72.5 134.07,72.25 134.56,72.25 134.95,71.87 134.95,71.83 134.96,71.82
  IN2 w0.122: v2(38.42,35.46) 38.25,35.46 38.08,35.29 38.08,34.79 38.58,34.29 50.29,34.29 53.2,31.39 84.65,31.39 85.06,31.79 90.11,31.79 90.46,31.44 92.3,31.44 93.2,32.35 95.12,32.35 95.52,32.75 96.8,32.75 97.42,32.13 100.95,32.13 101.42,32.61 110.3,32.61 110.79,33.1 119.5,33.1 119.82,33.41 130.21,33.41 130.41,33.61 130.88,33.61 135.64,38.38 135.64,41.48 138.79,44.63 142.48,44.63 143.27,45.42 143.27,56.44 143.04,56.67 143.04,63.71 138.68,68.07 138.68,70.3 137.96,71.02 135.77,71.02 134.96,71.82
  BOTTOM w0.076: v2(133.5,72.77) 133.63,72.77 133.82,72.58 UC1.E22
  BOTTOM w0.097: v2(38.42,35.46) 38.22,35.46 38.06,35.3 38.06,34.95 38.15,34.86 38.31,34.86 38.37,34.79 JSSD1.5
PCIE_CRX_NVMETX_N10: length 160.8
  IN2 w0.076: 134.96,72.83 134.95,72.84 134.95,72.96 134.77,73.14 134.15,73.14 133.98,73.31 133.98,73.44 133.85,73.57 133.85,73.7 133.72,73.83 133.61,73.83 v2(133.5,73.72)
  IN2 w0.122: 134.96,72.83 136.1,71.69 138.24,71.69 139.35,70.58 139.35,68.45 143.29,64.51 143.29,64.42 143.79,63.92 143.79,61.51 145.43,59.87 145.43,58.25 147.49,56.19 147.49,52.17 147.21,51.9 145.09,51.9 144.41,51.21 144.41,45.61 142.76,43.96 139.35,43.96 136.37,40.98 136.37,38.15 131.16,32.94 130.69,32.94 130.49,32.73 120.1,32.73 119.78,32.42 111.07,32.42 110.58,31.93 101.94,31.93 101.47,31.46 96.98,31.46 96.35,32.08 95.8,32.08 95.4,31.67 93.48,31.67 92.52,30.71 89.92,30.71 89.52,31.12 85.37,31.12 84.96,30.71 52.92,30.71 50.01,33.62 39.02,33.62 38.74,33.34 38.74,33.06 v2(38.59,32.9)
  BOTTOM w0.076: v2(133.5,73.72) 133.5,74 133.37,74.14 UC1.F25
  BOTTOM w0.097: JSSD1.17 35.37,33.31 35.06,33 35.06,32.79 35.36,32.49 38.69,32.49 38.78,32.59 38.78,32.7 v2(38.59,32.9)
PCIE_CRX_NVMETX_N11: length 165.7
  IN2 w0.122: v2(134.08,75.51) 134.08,75.25 134.14,75.19 134.54,75.19 134.68,75.33 135.35,75.33 138.07,72.62 138.62,72.62 140.49,70.75 140.49,69.2 140.69,69.01 140.69,68.61 144.67,64.63 146.17,64.63 146.66,64.14 146.66,61.78 147.29,61.15 147.29,57.76 148.44,56.61 148.44,51.26 145.53,48.35 145.53,45.42 143.14,43.03 139.73,43.03 137.35,40.65 137.35,37.82 130.86,31.33 119.75,31.33 119.59,31.5 111.46,31.5 110.97,31.01 102.33,31.01 101.85,30.53 96.58,30.53 96.53,30.48 93.59,30.48 92.9,29.79 89.39,29.79 88.98,30.19 85.79,30.19 85.38,29.79 51.85,29.79 49.9,31.74 45.4,31.74 45.02,32.12 38.16,32.12 38.01,32.27 35.29,32.27 34.83,31.81 34.83,31.71 v2(35.04,31.51)
  BOTTOM w0.076: v2(134.08,75.51) 133.99,75.51 133.87,75.64 133.87,75.93 UC1.E28
  BOTTOM w0.097: v2(35.04,31.51) 34.79,31.76 34.79,31.92 34.56,32.15 32.75,32.15 32.24,32.67 32.24,33.12 32.37,33.26 JSSD1.29
PCIE_CRX_NVMETX_N12: length 170.8
  IN2 w0.122: v2(134.19,76.37) 134.12,76.44 134.12,76.6 134.24,76.73 134.56,76.73 138.25,73.04 138.8,73.04 140.92,70.92 140.92,70.1 143.31,67.71 143.31,67.25 145.45,65.11 146.29,65.11 147.18,64.22 147.18,61.92 147.72,61.38 147.72,57.94 148.87,56.79 148.87,51.08 145.96,48.17 145.96,45.24 143.32,42.6 140.37,42.6 137.77,40.01 137.77,37.64 131.04,30.91 119.35,30.91 119.19,31.07 111.63,31.07 111.14,30.58 102.5,30.58 102.03,30.1 96.76,30.1 96.52,29.87 93.59,29.87 93.08,29.36 51.45,29.36 49.51,31.29 36.33,31.29 36.2,31.41 36.2,31.64 36.33,31.76 v2(36.4,31.76)
  BOTTOM w0.076: v2(134.19,76.37) 133.97,76.37 133.8,76.54 133.8,76.86 UC1.E30
  BOTTOM w0.097: JSSD1.43 28.87,33.18 29.03,33.03 29.09,33.03 29.19,32.93 29.19,32 30.45,30.73 35.85,30.73 36.06,30.94 36.06,31.02 36.2,31.16 36.2,31.56 v2(36.4,31.76)
PCIE_CRX_NVMETX_P9: length 151.6
  IN2 w0.076: v2(134.14,72.77) 134.02,72.65 134.02,72.53 134.14,72.42 134.69,72.42 135.09,72.01 135.12,72.01 135.14,72
  IN2 w0.122: 135.14,72 135.87,71.27 138.06,71.27 138.93,70.4 138.93,68.18 143.28,63.82 143.28,56.77 143.51,56.54 143.51,45.32 142.58,44.38 138.9,44.38 135.89,41.37 135.89,38.27 130.98,33.37 130.51,33.37 130.31,33.16 119.92,33.16 119.61,32.85 110.9,32.85 110.41,32.36 101.52,32.36 101.05,31.89 97.32,31.89 96.7,32.51 95.63,32.51 95.22,32.1 93.3,32.1 92.4,31.2 90.35,31.2 90.01,31.54 85.16,31.54 84.76,31.14 53.1,31.14 50.19,34.04 38.48,34.04 37.83,34.69 37.83,35.28 v2(37.67,35.44)
  BOTTOM w0.076: UC1.E23 133.82,73.03 134.08,72.77 v2(134.14,72.77)
  BOTTOM w0.097: v2(37.67,35.44) 37.67,35.4 37.87,35.2 JSSD1.7
PCIE_CRX_NVMETX_P10: length 160.8
  IN2 w0.076: v2(134.22,73.72) 134.15,73.65 134.15,73.38 134.22,73.3 134.84,73.3 135.14,73.01
  IN2 w0.122: 135.14,73.01 136.2,71.94 138.34,71.94 139.6,70.68 139.6,68.55 143.54,64.61 143.54,64.52 144.04,64.02 144.04,61.62 145.68,59.97 145.68,58.35 147.74,56.29 147.74,52.07 147.32,51.65 145.2,51.65 144.66,51.11 144.66,45.5 142.86,43.71 139.45,43.71 136.62,40.88 136.62,38.05 131.26,32.69 130.79,32.69 130.59,32.49 120.2,32.49 119.89,32.17 111.18,32.17 110.69,31.68 102.05,31.68 101.57,31.21 96.87,31.21 96.25,31.83 95.91,31.83 95.5,31.42 93.58,31.42 92.62,30.46 89.82,30.46 89.41,30.87 85.48,30.87 85.07,30.46 52.82,30.46 49.91,33.37 39.12,33.37 38.99,33.24 38.99,33.08 v2(39.17,32.9)
  BOTTOM w0.076: UC1.E25 133.82,74.12 v2(134.22,73.72)
  BOTTOM w0.097: v2(39.17,32.9) 38.97,32.7 38.97,32.51 38.77,32.3 35.28,32.3 34.87,32.71 JSSD1.19
PCIE_CRX_NVMETX_P11: length 165.7
  IN2 w0.122: v2(34.46,31.51) 34.59,31.63 34.59,31.91 35.19,32.52 38.11,32.52 38.26,32.37 45.12,32.37 45.5,31.99 50,31.99 51.96,30.03 85.28,30.03 85.69,30.44 89.08,30.44 89.49,30.03 92.8,30.03 93.49,30.72 96.42,30.72 96.48,30.78 101.75,30.78 102.22,31.25 110.86,31.25 111.35,31.75 119.69,31.75 119.86,31.58 130.76,31.58 137.1,37.92 137.1,40.75 139.63,43.28 143.04,43.28 145.28,45.52 145.28,48.45 148.19,51.36 148.19,56.51 147.04,57.66 147.04,61.04 146.41,61.68 146.41,64.04 146.07,64.38 144.57,64.38 140.44,68.51 140.44,68.91 140.24,69.1 140.24,70.64 138.52,72.37 137.97,72.37 135.25,75.08 134.78,75.08 134.64,74.94 134.04,74.94 133.5,75.48 v2(133.5,75.51)
  BOTTOM w0.076: UC1.E27 133.82,75.19 v2(133.5,75.51)
  BOTTOM w0.097: JSSD1.31 31.87,33.29 32.05,33.11 32.05,32.59 32.67,31.96 34.48,31.96 34.6,31.84 34.6,31.65 v2(34.46,31.51)
PCIE_CRX_NVMETX_P12: length 170.9
  IN2 w0.122: v2(133.5,76.33) 134.14,76.98 134.67,76.98 138.35,73.29 138.9,73.29 141.17,71.03 141.17,70.21 143.56,67.81 143.56,67.36 145.56,65.36 146.4,65.36 147.43,64.32 147.43,62.02 147.97,61.49 147.97,58.04 149.12,56.89 149.12,50.98 146.21,48.07 146.21,45.14 143.42,42.36 140.47,42.36 138.02,39.91 138.02,37.54 131.14,30.66 119.25,30.66 119.08,30.82 111.74,30.82 111.25,30.33 102.61,30.33 102.13,29.86 96.86,29.86 96.62,29.62 93.69,29.62 93.18,29.11 51.34,29.11 49.41,31.04 36.22,31.04 35.94,31.33 v2(35.8,31.33)
  BOTTOM w0.076: UC1.F30 133.33,76.88 133.5,76.72 v2(133.5,76.33)
  BOTTOM w0.097: v2(35.8,31.33) 35.87,31.25 35.87,31.02 35.78,30.92 30.53,30.92 29.37,32.08 JSSD1.41
PCIE_CRX_WLANTX_N6: length 121.3
  IN2 w0.076: 135.01,87.94 134.99,87.94 134.93,87.88 132.52,87.88 132.16,87.52 132.16,77.59 131.57,77 131.57,71.79 131.04,71.26 131.04,70.69 131.39,70.35 132.98,70.35 133.07,70.26 133.07,70.2 133.07,70.15 v2(132.85,69.92)
  IN2 w0.122: v2(75.49,124.88) 75.62,124.75 75.62,124.48 75.92,124.18 79.53,124.18 80.42,123.28 86.6,123.28 87.98,121.9 118.74,121.9 132.99,107.64 132.99,105.62 138.45,100.17 138.45,91 135.38,87.94 135.01,87.94
  BOTTOM w0.076: UC1.G18 132.85,69.89 v2(132.85,69.92)
  BOTTOM w0.097: JWLAN1.43 78.1,132.05 77.95,131.89 77.55,131.89 76.68,131.03 76.68,129.17 76.05,128.53 76.05,126.12 75.49,125.56 v2(75.49,124.88)
PCIE_CRX_WLANTX_P6: length 121.2
  IN2 w0.076: v2(133.5,69.93) 133.27,70.15 133.27,70.34 133.06,70.55 131.47,70.55 131.24,70.78 131.24,71.18 131.78,71.71 131.78,76.92 132.36,77.5 132.36,87.43 132.65,87.71 134.97,87.71 134.99,87.69 135.01,87.69
  IN2 w0.122: 135.01,87.69 135.48,87.69 138.7,90.9 138.7,100.27 133.24,105.72 133.24,107.75 118.84,122.15 88.08,122.15 86.7,123.53 80.52,123.53 79.63,124.42 76.03,124.42 75.87,124.58 75.87,124.67 v2(76.07,124.88)
  BOTTOM w0.076: UC1.F18 133.5,69.89 v2(133.5,69.93)
  BOTTOM w0.097: JWLAN1.41 78.1,131.55 77.95,131.71 77.63,131.71 76.87,130.95 76.87,129.09 76.23,128.46 76.23,126.04 75.68,125.48 75.68,125.27 v2(76.07,124.88)
PCIE_CTX_C_LANRX_N5: length 2.3
  TOP w0.097: CL4.2 28.22,86.25 v3(27.67,86.25) 27.12,86.25 27.08,86.21 UL1.14
PCIE_CTX_C_LANRX_P5: length 2.3
  TOP w0.097: CL3.2 28.44,86.03 27.23,86.03 27.01,85.81 UL1.13
PCIE_CTX_C_NVMERX_N9: length 2.3
  BOTTOM w0.097: CS16.2 36.68,35.68 36.68,35.14 36.87,34.95 JSSD1.11
PCIE_CTX_C_NVMERX_N10: length 2.2
  BOTTOM w0.097: CS18.2 33.76,35.74 33.76,35.06 33.87,34.95 JSSD1.23
PCIE_CTX_C_NVMERX_N11: length 2.3
  BOTTOM w0.097: JSSD1.35 30.87,34.79 30.7,34.97 30.7,35.67 CS20.2
PCIE_CTX_C_NVMERX_N12: length 2.4
  BOTTOM w0.097: CS22.2 27.97,35.67 27.97,35.48 27.72,35.22 27.72,34.99 27.87,34.83 JSSD1.47
PCIE_CTX_C_NVMERX_P9: length 2.3
  BOTTOM w0.097: CS17.2 36.49,35.56 36.49,35.06 36.37,34.95 JSSD1.13
PCIE_CTX_C_NVMERX_P10: length 2.3
  BOTTOM w0.097: CS19.2 33.57,35.68 33.57,35.14 33.37,34.95 JSSD1.25
PCIE_CTX_C_NVMERX_P11: length 2.2
  BOTTOM w0.097: JSSD1.37 30.37,34.82 30.51,34.96 30.51,35.75 CS21.2
PCIE_CTX_C_NVMERX_P12: length 2.3
  BOTTOM w0.097: JSSD1.49 27.37,34.83 27.53,34.99 27.53,35.3 27.79,35.56 27.79,35.75 CS23.2
PCIE_CTX_C_WLANRX_N6: length 4.2
  BOTTOM w0.097: JWLAN1.37 79.8,130.55 79.84,130.51 80.34,130.51 v3(81.34,129.51) 81.76,129.09 81.76,128.63 CW1.2
PCIE_CTX_C_WLANRX_P6: length 4.1
  BOTTOM w0.097: JWLAN1.35 79.77,130.05 80.05,130.33 80.26,130.33 80.98,129.61 80.98,129.55 81.39,129.14 81.44,129.14 81.57,129.01 81.57,128.73 81.22,128.37 CW2.2
PCIE_CTX_LANRX_N5: length 218.6
  TOP w0.097: v2(31.19,85.95) 30.83,86.31 30.65,86.49 30.31,86.49 30.09,86.27 29.85,86.27 29.57,86.54 CL4.1
  IN2 w0.122: v2(149.43,78.09) 149.69,78.34 149.69,80.51 147.32,82.88 140.25,82.88 139.61,83.53 139.61,89.96 140.06,90.41 140.06,101.44 134.53,106.97 134.53,108.23 119.36,123.4 104.9,123.4 104.42,123.89 101.31,123.89 100.83,123.4 88.6,123.4 87.22,124.79 81.04,124.79 79.72,126.11 76.2,126.11 75.73,126.58 74.59,126.58 74.12,126.11 66.24,126.11 63.19,123.06 43.65,123.06 24.24,103.65 23.54,103.65 20.48,100.58 20.48,94.78 22.01,93.24 27.18,93.24 29.75,90.68 29.75,87 29.98,86.76 30.56,86.76 30.86,86.47 30.86,86.29 31.19,85.96 v2(31.19,85.95)
  BOTTOM w0.076: 139,69.54 138.98,69.54 138.97,69.53 138.59,69.53 138.43,69.69 137.04,69.69 136.43,70.3 136.15,70.3 136.01,70.31 135.91,70.27 135.83,70.27 135.83,70.27 135.68,70.31 135.45,70.33 135.33,70.26 135.01,70.24 134.9,70.35 134.9,70.63 134.96,70.7 135.12,70.7 135.25,70.58 UC1.C19
  BOTTOM w0.097: 139,69.54 139.9,69.54 145.48,75.12 147.4,75.12 149.83,77.55 149.83,77.71 149.45,78.09 v2(149.43,78.09)
PCIE_CTX_LANRX_P5: length 218.6
  TOP w0.097: v2(30.61,85.95) 30.7,86.04 30.7,86.18 30.57,86.3 30.39,86.3 30.17,86.08 29.85,86.08 CL3.1
  IN2 w0.122: v2(30.61,85.95) 30.61,86.37 30.46,86.51 29.88,86.51 29.5,86.89 29.5,90.58 27.08,92.99 21.91,92.99 20.23,94.67 20.23,100.68 23.44,103.9 24.13,103.9 43.54,123.31 63.08,123.31 66.14,126.36 74.02,126.36 74.48,126.83 75.83,126.83 76.3,126.36 79.83,126.36 81.15,125.03 87.32,125.03 88.71,123.65 100.72,123.65 101.21,124.14 104.52,124.14 105.01,123.65 119.47,123.65 134.78,108.34 134.78,107.07 140.31,101.54 140.31,90.31 139.85,89.86 139.85,83.63 140.36,83.13 147.42,83.13 149.94,80.61 149.94,78.17 v2(150.02,78.09)
  BOTTOM w0.076: UC1.D19 134.73,70.41 134.73,70.28 134.95,70.07 135.38,70.1 135.49,70.16 135.65,70.15 135.75,70.12 135.77,70.1 135.95,70.1 136.04,70.14 136.12,70.14 136.14,70.14 136.36,70.14 136.97,69.53 138.36,69.53 138.52,69.36 138.97,69.36 138.98,69.35 139,69.35
  BOTTOM w0.097: 139,69.35 139.98,69.35 145.52,74.9 v3(146.49,74.9) 147.44,74.9 150.02,77.48 v2(150.02,78.09)
PCIE_CTX_NVMERX_N9: length 174.6
  IN2 w0.122: v2(140.36,73.35) 140.24,73.35 140.09,73.19 140.09,73.06 141.84,71.31 141.84,70.64 144.23,68.24 144.23,67.78 145.94,66.07 146.64,66.07 148.11,64.6 148.11,62.36 148.64,61.83 148.64,58.32 149.79,57.17 149.79,50.7 146.88,47.79 146.88,44.86 143.7,41.68 141,41.68 138.7,39.38 138.7,37.26 131.42,29.98 118.33,29.98 117.88,29.53 113.12,29.53 112.6,30.05 111.93,30.05 111.53,29.65 102.89,29.65 102.01,28.77 95.75,28.77 95.64,28.89 94.59,28.89 94.14,28.43 87.08,28.43 86.42,27.78 57.01,27.78 56.35,28.43 51.06,28.43 49.13,30.37 34.66,30.37 33.61,31.42 33.61,35.19 34.37,35.95 34.37,37.76 34.81,38.2 35.26,38.2 v2(35.34,38.27)
  BOTTOM w0.076: 140.36,73.51 140.36,73.54 140.53,73.71 140.53,74.1 140.19,74.44 139.72,74.44 139.58,74.58 137.85,74.58 136.74,73.48 136.27,73.48 136.01,73.22 136.01,73.15 UC1.B23
  BOTTOM w0.097: 140.36,73.51 v2(140.36,73.35) ; v2(35.34,38.27) 36.14,38.27 36.74,37.67 36.74,37.29 CS16.1
PCIE_CTX_NVMERX_N10: length 179.7
  IN2 w0.122: v2(32.93,38.54) 32.76,38.37 32.43,38.37 32.02,37.96 32.02,31.81 34.14,29.68 48.86,29.68 50.78,27.76 56.07,27.76 56.73,27.1 86.7,27.1 87.36,27.76 97.52,27.76 97.86,28.1 102.29,28.1 102.92,28.73 112.2,28.73 112.31,28.83 112.8,28.83 112.84,28.79 131.19,28.79 139.37,36.98 139.37,39.1 141.28,41 143.98,41 147.56,44.58 147.56,47.51 150.47,50.42 150.47,57.45 149.32,58.6 149.32,60.09 149.69,60.46 149.69,64.44 147.38,66.75 146.21,66.75 144.91,68.06 144.91,68.52 142.52,70.92 142.52,71.76 141.02,73.25 141.02,73.91 140.28,74.66 139.59,74.66 139.43,74.82 138.85,74.82 138.44,74.42 138.44,74.11 138.51,74.04 v2(138.51,73.74)
  BOTTOM w0.076: v2(138.51,73.74) 138.25,74 138.11,74 137.68,73.56 137.68,73.39 136.9,72.61 135.76,72.61 135.68,72.63 135.25,72.63 134.85,73.03 UC1.D23
  BOTTOM w0.097: CS18.1 33.99,37.06 33.99,37.87 33.55,38.31 33.17,38.31 v2(32.93,38.54)
