# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Nets (continued)
LANWAKE#: RC85.2 UC1.AM15 UE1.35
LANXIN: RL8.2 UL1.28
LANXIN_R: CL10.1 RL8.1 YL1.1
LANXOUT: RL9.2 UL1.29
LANXOUT_R: CL11.1 RL9.1 YL1.3
LCD_BRIGHTNESS: JEDP1.27 RP2.2
LCD_CBL_DET#: JEDP1.14 RC205.1 UC1.W4
LCD_TST: D3.3 RP2.6 UE1.26
LCD_TST_C: JEDP1.10 RP2.3
LCD_VCC_TEST_EN: D4.3 UE1.113
LCDVDD_EN: D4.1 R10.1 U1.4
LDO1_CAP: CA20.2 RA41.2 UA1.27
LDO2_CAP: CA21.2 UA1.39
LDO3_CAP: CA22.2 UA1.7
LED1: RL17.2 UL1.26
LG_1.2V: PQM01.8 PUM01.15
LG_VCCSA: PQA01.8 PUA01.5
LGATE_CHG: PQB02.4 PUB01.21
LID_CL_SIO#: CE19.1 D5.1 R22.1 RE25.2 UE1.66
LID_CLOSE#: EC2902.1 JPWR1.3 R22.2
LINE1-L_C: CA32.2 RA28.1
LINE1-L_R: CA33.2 RA32.1
LINE1_L: CA32.1 UA1.22
LINE1_R: CA33.1 UA1.21
LOM_TCT: CL12.1 TL1.11 TL1.14 TL2.11 TL2.14
LX_1.2V: PCM12.2 PLM01.2 PQM01.9 PRM01.1 PUM01.16
LX_1.8VALW: PL1801.1 PR1804.1 PU1801.2 PU1801.3
LX_3V: PC307.2 PL301.1 PR305.1 PU301.6 PU301.19 PU301.20
LX_5V: PC507.2 PL501.1 PR505.1 PU501.6 PU501.19 PU501.20
LX_+1VALW: PCH12.2 PLH01.1 PRH07.1 PUH01.2 PUH01.3
LX_VCCSA: PCA07.2 PLA01.1 PQA01.9 PRA02.1 PUA01.7
LX_VCORE1: PLI01.1 PRI03.1 PUI01.11 PUI01.12
LX_VCORE2: PLI02.1 PRI23.1 PUI02.11 PUI02.12
LX_VGT1: PLG01.1 PRG03.1 PUG01.11 PUG01.12
M2_SSD_PEDET: JSSD1.69 RS2.1 UC1.G4
MASK_SATA_LED#: Q22.2 R23.2 RC224.2 UE1.56
MCT: CL13.1 RL14.1 RL15.1 RL19.1 RL20.1
MCT0: RL15.2 TL1.3
MCT1: RL14.2 TL1.6
MCT2: RL19.2 TL2.6
MCT3: RL20.2 TL2.3
MDO0+: JLAN1.1 TL1.1
MDO0-: JLAN1.2 TL1.2
MDO1+: JLAN1.3 TL1.7
MDO1-: JLAN1.6 TL1.8
MDO2+: JLAN1.4 TL2.8
MDO2-: JLAN1.5 TL2.7
MDO3+: JLAN1.7 TL2.2
MDO3-: JLAN1.8 TL2.1
ME_FWP: RC126.1 RE19.1 UE1.80
MEC_XTAL1: CE3.1 RE47.2 YE1.1
MEC_XTAL1_R: RE47.1 UE1.123
MEC_XTAL2: CE4.1 RE45.1 UE1.125 YE1.2
MEM_SMBCLK: QC1.6 RPC3.1 UC1.R7
MEM_SMBDATA: QC1.3 RPC3.2 UC1.R8
MIC_CAP: CA26.1 UA1.19
MODEL_ID: CE1.1 RE3.2 RE4.2 UE1.109
MSCLK: JDEG1.6 RE55.2
MSDATA: JDEG1.7 RE56.2 RE62.1
NB_MUTE#: RE28.1 UE1.119
NCT7718_DXN: C22.2 C23.2 Q14.3 U2.3
NCT7718_DXP: C22.1 C23.1 Q14.1 Q14.2 U2.2
NRB_BIT: RC44.2 UC1.AR7
ONE_DIMM#: RC181.2 RC182.1 UC1.AP7
PANEL_BKEN_EC: RP2.8 UE1.117
PBAT_CHG_SMBCLK: PD5.3 PR42.2 PRB18.1 RE9.1 UE1.9
PBAT_CHG_SMBDAT: PD5.2 PR37.2 PRB17.1 RE8.1 UE1.8
PBAT_PRES#: CE16.1 PC14.1 PCB31.1 PD6.2 PR39.2 PR41.1 PRB40.1 PRB42.1 UE1.29
PCH_BATLOW#: RC89.1 UC1.AU13
PCH_DPWROK: RC87.1 RC97.2 UC1.BB20
PCH_ESPI_CLK: RC15.1 UC1.AW9
PCH_ESPI_IO0: RPC2.1 UC1.AY13
PCH_ESPI_IO1: RPC2.2 UC1.BA13
PCH_ESPI_IO2: RPC2.3 UC1.BB13
PCH_ESPI_IO3: RPC2.4 UC1.AY12
PCH_JTAG_TCK1: RC147.1 TPC3.1(TP-1) UC1.B56
PCH_PCIE_WAKE#: RC99.2 UC1.BB15
PCH_PLTRST#: RC108.1 UC1.AN10 UC4.1 UC4.2 UM2.2
PCH_POPIRCOMP: RC120.1 UC1.AU16
PCH_RSMRST#: RE20.1 UC5.1 UE1.27
PCH_RSMRST#_Q: RC94.2 RC97.1 RC148.1 UC1.AY17 UC5.4
PCH_RTCRST#: CC5.1 JCMOS1.1 QC2.1 RC78.1 UC1.AM16
PCH_RTCX1: CC8.1 RC82.2 UC1.AM18 YC2.1
PCH_RTCX2: CC9.1 RC82.1 UC1.AM20 YC2.2
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JVGA.12 QC1.1 RC28.2 US1.1
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JVGA.11 QC1.4 RC27.2 US1.4
PCH_SPI_CLK: RC21.2 RC178.2 RX3.1 UC1.AV2
PCH_SPI_CLK_R: RC178.1 UC3.6
PCH_SPI_CLK_TPM: RX3.2 UX1.19
PCH_SPI_CS#0: RC18.2 UC1.AU3 UC3.1
PCH_SPI_CS#2: UC1.AU1 UX1.20
PCH_SPI_D0: RC40.2 RC179.2 RX2.1 UC1.AV3
PCH_SPI_D0_R: RC179.1 UC3.5
PCH_SPI_D0_TPM: RX2.2 UX1.21
PCH_SPI_D1: RC180.2 RX1.1 UC1.AW3
PCH_SPI_D1_R: RC180.1 UC3.2
PCH_SPI_D1_TPM: RX1.2 UX1.24
PCH_SPI_D2: RC19.2 RC41.2 RC176.1 UC1.AW2
PCH_SPI_D2_R: RC176.2 UC3.3
PCH_SPI_D3: RC20.2 RC177.1 UC1.AU4
PCH_SPI_D3_R: RC177.2 UC3.7
PCIE_CRX_C_LANTX_N5: CL2.2 UL1.18
PCIE_CRX_C_LANTX_P5: CL1.2 UL1.17
PCIE_CRX_LANTX_N5: CL2.1 UC1.F16
PCIE_CRX_LANTX_P5: CL1.1 UC1.E16
PCIE_CRX_NVMETX_N9: JSSD1.5 UC1.E22
PCIE_CRX_NVMETX_N10: JSSD1.17 UC1.F25
PCIE_CRX_NVMETX_N11: JSSD1.29 UC1.E28
PCIE_CRX_NVMETX_N12: JSSD1.43 UC1.E30
PCIE_CRX_NVMETX_P9: JSSD1.7 UC1.E23
PCIE_CRX_NVMETX_P10: JSSD1.19 UC1.E25
PCIE_CRX_NVMETX_P11: JSSD1.31 UC1.E27
PCIE_CRX_NVMETX_P12: JSSD1.41 UC1.F30
PCIE_CRX_WLANTX_N6: JWLAN1.43 UC1.G18
PCIE_CRX_WLANTX_P6: JWLAN1.41 UC1.F18
PCIE_CTX_C_LANRX_N5: CL4.2 UL1.14
PCIE_CTX_C_LANRX_P5: CL3.2 UL1.13
PCIE_CTX_C_NVMERX_N9: CS16.2 JSSD1.11
PCIE_CTX_C_NVMERX_N10: CS18.2 JSSD1.23
PCIE_CTX_C_NVMERX_N11: CS20.2 JSSD1.35
PCIE_CTX_C_NVMERX_N12: CS22.2 JSSD1.47
PCIE_CTX_C_NVMERX_P9: CS17.2 JSSD1.13
PCIE_CTX_C_NVMERX_P10: CS19.2 JSSD1.25
PCIE_CTX_C_NVMERX_P11: CS21.2 JSSD1.37
PCIE_CTX_C_NVMERX_P12: CS23.2 JSSD1.49
PCIE_CTX_C_WLANRX_N6: CW1.2 JWLAN1.37
PCIE_CTX_C_WLANRX_P6: CW2.2 JWLAN1.35
PCIE_CTX_LANRX_N5: CL4.1 UC1.C19
PCIE_CTX_LANRX_P5: CL3.1 UC1.D19
PCIE_CTX_NVMERX_N9: CS16.1 UC1.B23
PCIE_CTX_NVMERX_N10: CS18.1 UC1.D23
PCIE_CTX_NVMERX_N11: CS20.1 UC1.D24
PCIE_CTX_NVMERX_N12: CS22.1 UC1.A25
PCIE_CTX_NVMERX_P9: CS17.1 UC1.A23
PCIE_CTX_NVMERX_P10: CS19.1 UC1.C23
PCIE_CTX_NVMERX_P11: CS21.1 UC1.C24
PCIE_CTX_NVMERX_P12: CS23.1 UC1.B25
PCIE_CTX_WLANRX_N6: CW1.1 UC1.D20
PCIE_CTX_WLANRX_P6: CW2.1 UC1.C20
PCIE_RCOMPN: RC65.1 UC1.F5
PCIE_RCOMPP: RC65.2 UC1.E5
PCIE_WAKE#: JSSD1.54 RC99.1 RE12.2 UE1.4 UL1.21
PECI_EC: DE1.1 RE23.2 UC1.A54
PHASE_CHG: PCB15.2 PLB01.1 PQB01.1 PQB01.2 PQB01.3 PQB02.5 PRB22.1 PUB01.22
PHASE_VCORE1: PCI09.2 PUI01.7
PHASE_VCORE2: PCI29.2 PUI02.7
PHASE_VGT1: PCG09.2 PUG01.7
PLTRST#: JSSD1.50 JWLAN1.52 RC108.2 RC109.1 RE65.1 UC4.4 UL1.19 UX1.17
PME#: TP12.1(TP-1) UC1.AU11
POK: CC10.1 PR35.1 PR304.2 PR504.2 PR1801.1 PRH01.1 PU301.9 PU501.9 RC102.1 UC5.2
POWER_SW#_MB: EC2901.1 ED2901.3 JPWR1.2 RE43.2 SW1.1 TPS8.1(TP-1)
POWER_SW_IN#: CE33.1 RE41.2 RE43.1 UE1.127
PRIM_PWRGD: PR1803.2 PU1801.4 UE1.30
PROCHOT: RE53.2 UE1.83 UE2.2
PROG: PRB37.1 PUB01.9
PROH: PQB05.2 PRB19.2 PRB29.2 PUB01.5
PROJECT_ID0: RC53.2 RC54.1 UC1.AK6
PROJECT_ID1: RC51.2 RC52.1 UC1.AK7
PS_ID: PD2.1 PR1.2 PR5.1 UE1.36
PSID: PJPDC1.3 PL3.1
PSID-1: PQ2.2 PR3.2 PR6.1
PSID-3: PQ1.3 PR1.1
PTP_DIS#: D6.1 UE1.90
PWM1_2PH_CPU: PUI01.1 PUZ01.16
PWM2_2PH_CPU: PUI02.1 PUZ01.17
PWM_1A_CPU: PUG01.1 PUZ01.22
PWM_1B_CPU: PUA01.2 PUZ01.36
REGOUT: CL15.1 RL1.1 UL1.24
RESET_OUT#: CE31.1 RE16.1 UC1.BA20 UE1.73
RING2: RA25.2 RA35.1 UA1.17
RING2_R: CA36.1 CA42.1 DA5.3 JHP1.4 RA35.2
ROSC_COREGT_CPU: PRZ64.1 PUZ01.14
ROSC_SAUS_CPU: PRZ60.1 PUZ01.15
RTC_DET#: Q1.1 RC46.1 UC1.P1
RTC_PWR: D1.3 Q1.2 R1.1 R2.1
RTCRST_ON: C40.1 D7.1 Q23.2 QC2.2 R75.1 R76.2 RC164.1 UE1.31
RUNPWROK: RE42.2 UE1.48
SATA3_CRX_C_HDDTX_N0: CS3.2 JHDD1.5
SATA3_CRX_C_HDDTX_P0: CS4.2 JHDD1.6
SATA3_CRX_HDDTX_N0: CS3.1 UC1.F20
SATA3_CRX_HDDTX_P0: CS4.1 UC1.E20
SATA3_CTX_C_HDDRX_N0: CS2.2 JHDD1.3
SATA3_CTX_C_HDDRX_P0: CS1.2 JHDD1.2
SATA3_CTX_HDDRX_N0: CS2.1 UC1.B21
SATA3_CTX_HDDRX_P0: CS1.1 UC1.A21
SATA_CRX_C_ODDTX_N1: CS10.1 JODD1.9 JODD1.10
SATA_CRX_C_ODDTX_P1: CS9.1 JODD1.11 JODD1.12
SATA_CRX_ODDTX_N1: CS10.2 UC1.G21
SATA_CRX_ODDTX_P1: CS9.2 UC1.F21
SATA_CTX_C_ODDRX_N1: CS11.1 JODD1.5 JODD1.6
SATA_CTX_C_ODDRX_P1: CS12.1 JODD1.3 JODD1.4
SATA_CTX_ODDRX_N1: CS11.2 UC1.D21
SATA_CTX_ODDRX_P1: CS12.2 UC1.C21
SATA_LED#: Q25.2 R77.2 R78.1 RC69.1 UC1.H1
SATA_LED#_R: Q22.3 Q25.3 R78.2 R80.2
SATA_ODD_DA#: JODD1.23 JODD1.24 TP46.1(TP-1)
SATA_ODD_PRSNT#: JODD1.15 JODD1.16 RC194.1 RE81.2 UC1.AB1
SCLK_CPU: PRZ46.1 PUZ01.34
SD_RCOMP: RC130.1 UC1.AB7
SDIO_CPU: PRZ48.1 PUZ01.32
SIO_EXT_WAKE#: RC47.1 UC1.AD3 UE1.116
SIO_PWRBTN#: RC93.2 UC1.BA15 UE1.52
SIO_SLP_A#: TPS6.1(TP-1) UC1.AN16
SIO_SLP_LAN#: RC88.1 TP10.1(TP-1) UC1.AW15
SIO_SLP_S0#: RE92.1 RX9.2 RX10.2 TPS2.1(TP-1) UC1.AT11 UC9.2
SIO_SLP_S3#: DZ4.1 RC103.1 RZ2.1 TPS3.1(TP-1) UC1.AP15 UC9.1 UZ3.3 UZ3.5
SIO_SLP_S4#: DZ5.1 PR2501.1 PRM08.1 RZ1.1 TPS4.1(TP-1) UC1.BA16
SIO_SLP_S5#: PQB07.2 TPS5.1(TP-1) UC1.AY16
SIO_SLP_SUS#: TP75.1(TP-1) UC1.AN15
SIO_SLP_WLAN#: TP11.1(TP-1) UC1.BB17
SLEEVE: RA26.2 RA38.1 UA1.18
SLEEVE_R: CA37.1 CA41.1 DA5.2 JHP1.3 RA38.2
SM_RCOMP0: RC10.1 UC1.AR18
SM_RCOMP1: RC11.1 UC1.AT18
SM_RCOMP2: RC12.1 UC1.AU18
SMB_ALERT#: RC37.1 UC1.R10
SML0_SMBCLK: RC33.1 UC1.R9
SML0_SMBDATA: RC34.1 UC1.W2
SML1_SMBCLK: Q11.3 RE11.1 RPC3.3 UC1.W3 UE1.12
SML1_SMBDATA: Q11.6 RE10.1 RPC3.4 UC1.V3 UE1.11
SNB_VCCSA: PCA09.1 PRA02.2
SNUB_+1VALW: PCH13.1 PRH07.2
SOC_XDP_TDI: RC141.1 TPC5.1(TP-1) UC1.D59 UC1.D60
SOC_XDP_TDO: RC142.1 TPC1.1(TP-1) UC1.A56 UC1.A61
SOC_XDP_TMS: RC140.1 TPC4.1(TP-1) UC1.C59 UC1.C60
SOC_XDP_TRST#: TPC6.1(TP-1) UC1.B59 UC1.C61
SPKR: DA3.3 RC128.2 UC1.AW5
SRTCRST#: CC4.1 RC77.1 UC1.AN18
SSD_DEVSLP: JSSD1.38 UC1.J3
SUSCLK: RC74.2 RC75.2 RC110.1 UC1.BA17
SUSCLK_EC: RC75.1 RE45.2
SUSCLK_WLAN: JWLAN1.50 RC74.1
SYS_PWROK: RE68.1 UC1.B6 UE1.28
SYS_RESET#: RC86.2 TPS1.1(TP-1) UC1.B5
SYSPWR_PRES: RE29.1 RE32.1 UE1.120
T_CRIT#: R29.2 U2.4
THM_SML1_CLK: Q11.4 R49.2 U2.8
THM_SML1_DATA: Q11.1 R48.2 U2.7
TON_1.2V: PRM07.2 PUM01.9
TOUCH_PAD_INTR#: DZ3.2 RC114.2 UC1.BA5
TOUCH_PANEL_PD#: RC118.2 UC1.AY5
TOUCH_SCREEN_PD#: D5.2 R19.2 RC115.2 RC118.1
TP_EN: C16.1 JEDP1.39 R19.1
TP_EN#: R38.1 UE1.49
TP_LOCK#: D6.2 JTP1.3 R41.2
TP_WAKE_KBC#: DZ3.1 Q9.1 RE14.1 UE1.33
TPM_ID: RC63.2 RC64.1 UC1.D8
TPM_SPI_IRQ#: RX4.2 UC1.M2 UX1.18
TSENSE_1PH_CPU: PCZ36.1 PRZ63.1 PUZ01.23
TSENSE_1PH_CPU_R: PHZ05.1 PRZ63.2 PRZ65.1
TSENSE_2PH_CPU: PCZ22.1 PRZ34.2 PUZ01.11
TSENSE_2PH_CPU_R: PHZ04.1 PRZ34.1 PRZ36.1
TX_P80DATA: JWLAN1.38 RW6.2
UART1_CTS#: TP79.1(TP-1) UC1.AB4
UART_P80: JWLAN1.32 RW10.2
UG_1.2V: PQM01.1 PUM01.17
UG_VCCSA: PQA01.1 PUA01.8
UGATE_CHG: PRB16.1 PUB01.23
USB2_ID: RC67.1 UC1.AG3
USB2_VBUSSENSE: RC68.1 UC1.AG4
USB3_CRX_DTX_N1: LU3.2 RU6.2 UC1.H8
USB3_CRX_DTX_N1_C: EU2601.1 EU2601.9 JUSB1.5 LU3.1 RU6.1
USB3_CRX_DTX_N3: LU6.2 RU12.2 UC1.J10
USB3_CRX_DTX_N3_C: EU2603.1 EU2603.9 JUSB2.5 LU6.1 RU12.1
USB3_CRX_DTX_P1: LU3.3 RU5.2 UC1.G8
USB3_CRX_DTX_P1_C: EU2601.2 EU2601.8 JUSB1.6 LU3.4 RU5.1
USB3_CRX_DTX_P3: LU6.3 RU11.2 UC1.H10
USB3_CRX_DTX_P3_C: EU2603.2 EU2603.8 JUSB2.6 LU6.4 RU11.1
USB3_CTX_DRX_N1: CU2.1 UC1.C13
USB3_CTX_DRX_N1_C: EU2601.4 EU2601.7 JUSB1.8 LU2.1 RU4.1
USB3_CTX_DRX_N1_R: CU2.2 LU2.2 RU4.2
USB3_CTX_DRX_N3: CU4.1 UC1.B15
USB3_CTX_DRX_N3_C: EU2603.4 EU2603.7 JUSB2.8 LU5.1 RU10.1
USB3_CTX_DRX_N3_R: CU4.2 LU5.2 RU10.2
USB3_CTX_DRX_P1: CU1.1 UC1.D13
USB3_CTX_DRX_P1_C: EU2601.5 EU2601.6 JUSB1.9 LU2.4 RU3.1
USB3_CTX_DRX_P1_R: CU1.2 LU2.3 RU3.2
USB3_CTX_DRX_P3: CU3.1 UC1.A15
USB3_CTX_DRX_P3_C: EU2603.5 EU2603.6 JUSB2.9 LU5.4 RU9.1
USB3_CTX_DRX_P3_R: CU3.2 LU5.3 RU9.2
USB20_VCC: CU17.1 JIOB1.13 JIOB1.14 JIOB1.15 JIOB1.16 UU3.1
USB30_VCCA: CU6.1 CU7.1 CU8.1 CU9.1 CU10.1 CU11.1 CU12.1 CU13.1 CU14.1 CU15.1 JUSB1.1 JUSB2.1 UU1.1
USB_CAMERA_EDP: JEDP1.34 L3.2 R18.1
USB_CAMERA_EDP#: JEDP1.33 L3.3 R17.1
USB_EN#: RE17.1 UE1.13 UU1.4 UU3.4
USB_OC0#: RPC1.3 UC1.A9 UU1.3
USB_OC1#: RPC1.2 UC1.C9 UU3.3
USB_OC2#: RPC1.1 UC1.D9
USB_OC3#: RPC1.4 UC1.B9
USB_PN1: LU1.3 RU1.1 UC1.AB9
USB_PN1_R: EU2602.3 JUSB1.2 LU1.4 RU1.2
USB_PN2: LU9.3 RU15.1 UC1.AD6
USB_PN2_R: JIOB1.7 LU9.4 RU15.2
USB_PN3: LU4.2 RU7.1 UC1.AH3
USB_PN3_R: EU2604.3 JUSB2.2 LU4.1 RU7.2
USB_PN5: L3.4 R17.2 UC1.AJ1
USB_PN6: LU8.3 RU13.1 UC1.AF6
USB_PN6_R: JIOB1.4 LU8.4 RU13.2
USB_PN7: JWLAN1.5 UC1.AH1
USB_PN8: L4.4 R20.2 UC1.AF8
USB_PN8_TPNL: DA6.3 JEDP1.36 L4.3 R20.1
USB_PN9: EU2701.2 JFP.4 JFP1.6 UC1.AG1
USB_PP1: LU1.2 RU2.1 UC1.AB10
USB_PP1_R: EU2602.2 JUSB1.3 LU1.1 RU2.2
USB_PP2: LU9.2 RU16.1 UC1.AD7
USB_PP2_R: JIOB1.6 LU9.1 RU16.2
USB_PP3: LU4.3 RU8.1 UC1.AJ3
USB_PP3_R: EU2604.2 JUSB2.3 LU4.4 RU8.2
USB_PP5: L3.1 R18.2 UC1.AJ2
USB_PP6: LU8.2 RU14.1 UC1.AF7
USB_PP6_R: JIOB1.3 LU8.1 RU14.2
USB_PP7: JWLAN1.3 UC1.AH2
USB_PP8: L4.1 R21.2 UC1.AF9
USB_PP8_TPNL: DA6.2 JEDP1.37 L4.2 R21.1
USB_PP9: EU2701.3 JFP.3 JFP1.5 UC1.AG2
USBCOMP: RC66.1 UC1.AB6
VCI_IN1: RE70.1 UE1.126
VCIN0_PH: C32.1 C33.1 R42.2 R43.2 RE37.2 RH1.1
VCREF0: CE23.1 RE46.2 RE48.1 UE1.25
VD_IN1_C: C32.2 C33.2 R45.1 RH1.2
VGA_CBL_DET#: JVGA.10 RC207.1 UC1.U4
VIDALERT_N: PRZ41.2 PRZ47.2 RC152.2 RC153.2
VIDSCLK: PRZ40.2 PRZ46.2 UC1.A63
VIDSOUT: PRZ42.2 PRZ48.2 RC154.2 UC1.D64
VL: PC515.1 PU501.15
VR_CAP: CE24.1 TP44.1(TP-1) UE1.18
VR_HOTL#: PRZ49.1 PUZ01.31
VRALERT#: RC92.1 UC1.AM11
VRMP_CPU: PCZ23.1 PRZ35.2 PUZ01.12
VSA_SEN+: PRZ03.1 RC159.2 UC1.H20
VSA_SEN-: PRZ07.1 RC160.1 UC1.H21
VSN_1A_CPU: PCZ28.1 PRZ52.1 PUZ01.25
VSN_1A_CPU_R: PCZ28.2 PCZ29.1 PRZ52.2 PRZ53.1
VSN_1B_CPU: PCZ07.2 PRZ08.2 PUZ01.44
VSN_2PH_CPU: PCZ11.2 PRZ19.2 PUZ01.48
VSN_2PH_CPU_R: PCZ10.2 PCZ11.1 PRZ18.2 PRZ19.1
VSNN_1B_CPU_R: PCZ06.2 PCZ07.1 PRZ07.2 PRZ08.1
VSP_1A_CPU: PCZ35.2 PRZ58.2 PUZ01.24
VSP_1A_CPU_R: PCZ29.2 PRZ58.1 PRZ59.2 PRZ61.1
VSP_1B_CPU: PCZ04.2 PRZ04.2 PUZ01.45
VSP_2PH_CPU: PCZ10.1 PRZ14.2 PUZ01.47
VSPP_1B_CPU_R: PCZ04.1 PCZ06.1 PRZ03.2 PRZ04.1
VTTREF_1.2V: PCM19.1 PUM01.4
WHITE_LED_BAT: C41.1 Q19.1 R69.2
WIFI_RF_EN: RC3.1 RW11.1 UC1.B7
XCLK_BIASREF: RC76.1 UC1.E42
XDP_HOOK0: RC148.2 TPC32.1(TP-1)
XDP_ITP_PMODE: RC143.2 TPC7.1(TP-1) UC1.E8
XDP_OBS0_R: TP15.1(TP-1) UC1.C55
XDP_OBS1_R: TP16.1(TP-1) UC1.D55
XDP_OBS2_R: TP17.1(TP-1) UC1.B54
XDP_OBS3_R: TP18.1(TP-1) UC1.C56
XDP_PRDY#: TPC31.1(TP-1) UC1.D56
XDP_PREQ#: TPC30.1(TP-1) UC1.D61
XDP_PRSENT_CPU: RC144.1 RC175.2 TPC33.1(TP-1)
XDP_SPI_IO2: RC41.1 RC145.1 TPC9.1(TP-1)
XDP_SPI_SI: RC40.1 RC139.2 TPC8.1(TP-1)
XTAL24_IN: RC23.1 UC1.E37
XTAL24_IN_R: CC6.1 RC23.2 RC80.2 YC1.3
XTAL24_OUT: RC24.1 UC1.E35
XTAL24_OUT_R: CC7.1 RC24.2 RC80.1 YC1.1
N17003752: JDIMM1.134 RD23.2
N17004366: JDIMM2.134 RD24.2
N17237617: PCB03.1 PCB04.1 PCB05.1 PCB06.1 PCB07.1 PCB08.1 PCB09.1 PCB10.1 PJPB01.2 PLB02.2 PQB01.5
N17268429: PQB05.1 PRB30.2 PRB31.1
N17283936: QA1.3 RA5.1 RA6.1
N17389450: PC516.1 PD501.2 PR502.2 PR503.2 PR506.2 PR508.1
N17415515: PJP2.1 PJPDC1.1 PJPDC1.2 PL2.1
N17442062: CZ3.1 UZ1.6
N17462309: JDEG1.9 RE58.2
N17462311: JDEG1.1 RE59.2
N17462343: JESPI1.8 RE65.2
N17569402: RA9.1 UA1.4
N17772976: PQB11.4 PRB04.1
N18346546: Q13.1 R37.1
N18346552: C18.2 Q12.2 Q13.2 R38.2
N18346555: C18.1 Q12.3 R35.2
N18390627: PQB07.1 PQB08.2
N18618528: TP28.1(TP-1) UC1.AY4
N18618529: TP29.1(TP-1) UC1.BB3
N18618530: TP27.1(TP-1) UC1.BB5
N18855880: R57.2 U1.3
N18983262: CE35.2 RE67.1
N18984098: CA38.2 RA43.1
N19485707: RX5.1 UX1.27
N19525376: CX5.1 CX6.1 CX7.1 RX6.2 RX7.2 UX1.14 UX1.22
N20558038: CC14.1 DZ4.2 RC103.2 UC6.2
N21174101: PBATT1.5 PR39.1
N21222441: PCB27.1 PRB27.2 PUB01.18
N21242279: PCB02.1 PQB03.3 PQB11.1 PQB11.2 PQB11.3 PQB12.1 PQB12.2 PQB12.3 PRB03.1 PRB08.1
N21269026: PCI32.1 PRI23.2
N21273981: PCG12.1 PRG03.2
N21380741: PC508.1 PU501.16 PU501.17
N21389189: PC1801.1 PJP1801.2 PL1811.2 PU1801.8 PU1801.9 PU1801.10
N22794228: QS1.5 QS1.6 RS3.2
N22795667: RS5.1 US2.3
N22796700: R30.1 U3.3
N22856216: TP48.1(TP-1) UL1.27
N22856217: TP49.1(TP-1) UL1.25
N22856235: RL2.2 UL1.31
N22856250: RL7.2 UL2.3
N22965608: RX8.1 UX1.2
N23213635: RC197.1 UC1.AY3
N23213778: RC198.1 UC1.AY71
N23239464: LED1.4 R68.1
N23239466: LED1.2 R69.1
N23484620: PRB39.1 PUB01.12
N23574846: PRB40.2 PUB01.13
N23700319: PD1.2 PL3.2 PQ1.1 PR3.1
N23938731: RE81.1 UE1.21
N24339159: TP76.1(TP-1) UC1.AN11
N24339162: TP77.1(TP-1) UC1.AN13
N24516732: RX9.1 UX1.3
N24516766: RX10.1 UX1.29
N24625686: Q24.1 R74.2
N24625731: C39.1 D7.2 Q24.2 R76.1
N24644647: JWLAN1.56 RW11.2
N24644650: JWLAN1.54 RW12.2
N24646002: Q15.2 R65.2 R67.1
N24646039: Q4.1 R67.2
N24646397: RE91.2 RE92.2 UE1.88
N24938879: JSSD1.10 R77.1
N25012168: Q25.5 Q25.6 R79.2
N25133961: DI1.3 RI13.2
N25133963: DI1.2 RI14.2
N27266810: PCB01.2 PCB02.2 PQB03.1 PQB12.4 PRB04.2 PRB07.1
N27286345: PDB01.1 PRB27.1
N28424999: TP30.1(TP-1) UC1.AW71
N28425002: TP31.1(TP-1) UC1.AW70
N28483977: PQ13.2 PR31.2 PR35.2 PR45.1
N28483985: PQ13.3 PR32.2
N28484391: PC13.1 PQ12.6 PR33.2
N28484395: PC13.2 PQ12.5 PR40.1
N28484412: PQ12.2 PR36.2 PR44.2
N28484439: PC14.2 PQ11.2 PR43.1
N28484451: PQ13.5 PQ13.6 PR34.2 PR38.1
N28714500: PRB17.2 PUB01.3
N28714504: PRB18.2 PUB01.4
N28714524: PCB13.1 PUB01.27
N28714534: PCB30.1 PRB38.2
N28714559: PRB20.2 PUB01.6
N28714562: PRB23.2 PUB01.7
N28714564: PCB15.1 PRB15.2
N28714583: PCB32.2 PRB41.2 PUB01.14
N28714585: PCB32.1 PRB34.2 PUB01.15
N28714598: PCB11.2 PRB06.2 PUB01.31
N28714599: PCB11.1 PRB05.2 PUB01.32
N28714601: PCB13.2 PUB01.28
N28714604: PRB12.1 PUB01.25
N28714606: PQB01.4 PRB16.2
N28714608: PRB10.2 PUB01.26
N28714612: PRB15.1 PUB01.24
N28714614: PRB25.1 PUB01.17
N28714617: PQB12.5 PRB02.1
N28714625: PRB25.2 PRB26.1
N28714693: PCB14.2 PLB01.2 PQB13.1 PQB13.2 PQB13.3 PRB01.1
N28714721: PRB01.2 PRB34.1
N28714724: PRB01.3 PRB41.1
N28714743: PQB03.2 PRB03.2 PRB43.1
N28714752: PRB02.2 PRB05.1
N28714753: PRB02.3 PRB06.1
N28714782: PCB18.1 PRB22.2
N28714793: PCB14.1 PQB13.4 PRB12.2
N28810503: CZ10.1 UZ3.12
N28810563: CZ11.1 UZ3.10
N28856399: TP19.1(TP-1) UC1.BA70
N28856402: TP20.1(TP-1) UC1.BA68
N28857231: TP21.1(TP-1) UC1.BB68
N28857234: TP22.1(TP-1) UC1.BB69
N28857237: TP23.1(TP-1) UC1.AK13
N28857240: TP24.1(TP-1) UC1.AK12
N28861827: RC138.1 UC1.C64
N28938912: CC2.2 RC21.1
N29708599: TP25.1(TP-1) UC1.AU5
N29708601: TP26.1(TP-1) UC1.AT5
N32842463: RC137.2 UC1.U11 UC1.U12
N33188643: CA31.1 RA23.2 RA24.1
N36085760: PD3.1 PR7.2
N36085833: PQ1.2 PQ2.1 PR4.2 PR7.1
N40598435: PC307.1 PR301.2
N40598500: PC507.1 PR501.2
N40598503: PC315.2 PR306.1
N40598539: PC517.2 PR509.1
N40598619: PD501.1 PR507.2
N41321201: PCB28.1 PQB06.2 PRB31.2
N45784517: PCZ02.1 PCZ08.1 PCZ09.1 PRZ06.2 PUZ01.41
N45784764: PRZ16.2 PUZ01.38
N45784907: PCZ26.2 PCZ27.2 PCZ33.1 PRZ51.2 PUZ01.28
N45784946: PCZ01.2 PRZ01.1
N45784991: PCZ13.1 PRZ20.2
N45785219: PCZ35.1 PRZ61.2
N45789065: PCI12.1 PRI03.2
N47599587: PCZ16.1 PRZ24.2
N47697054: PRH05.2 PUH01.7
N47701287: PCH11.1 PRH11.2 PUH01.11
N47701297: PCH10.1 PUH01.9
N47710281: PC2504.1 PR2504.2 PU2501.4
N47714748: PCM11.1 PRM01.2
N47719295: PCM13.1 PRM05.1 PUM01.12
N47772279: PCZ31.2 PRZ55.1
N47887852: PC1806.1 PR1804.2
N48572179: PCH14.2 PRH12.1
N124752685: CD30.2 RD11.1
N124753277: CD59.2 RD22.1
N260603521: PHZ01.2 PRZ10.1

Pads without a net: ED2901 2; EU4012 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 87 88 91 92 95 97 100 101 104 105 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 162 165; JEDP1 5 6 9 26; JHDMI1 13 14; JKB1 28 29; JKBBL1 3; JSSD1 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67 68; JWLAN1 6 16 17 19 20 21 22 23 24 25 27 28 29 30 31 34 36 40 42 44 46 48 55 58 59 60 61 62 64 65 66 67 68 70 71 73; PD1 3; PD6 3; PJPDC1 4; PU301 10 15; PU501 10; PU1801 1 7; PU2501 1 5; PUG01 6 13 17 19; PUI01 6 13 17 19; PUI02 6 13 17 19; RP1 4 5; RP2 4 5; TL1 4 5 12 13; TL2 4 5 12 13; UA1 11 12 14 15 23 24 48; UC1 A3 A4 A6 A7 A11 A13 A17 A19 A26 A27 A29 A31 A33 A36 A38 A45 A47 A50 A52 A65 A69 AB11 AB12 AB13 AB62 AC3 AC63 AD1 AD2 AD9 AD10 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK9 AK10 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL53 AL56 AL60 AL61 AL63 AM53 AM56 AM58 AN5 AN7 AN8 AP8 AP11 AP13 AP56 AR10 AR13 AR56 AT10 AT15 AU2 AU7 AU56 AU58 AU63 AW1 AW7 AW11 AW13 AW17 AW20 AW48 AW68 AW69 AY1 AY2 AY7 AY8 AY9 AY20 AY21 AY68 B2 B3 B11 B13 B17 B19 B26 B27 B29 B31 B33 B36 B38 B45 B47 B50 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BB2 BB4 BB7 BB9 BB11 BB57 BB66 C2 C4 C8 C11 C12 C15 C16 C17 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C42 C51 C54 C70 C71 D1 D3 D4 D5 D7 D12 D15 D16 D17 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D42 D51 D54 D71 E1 E2 E10 E38 E40 E61 F6 F10 F11 F15 F46 F50 F52 F60 F61 F65 G1 G2 G3 G11 G13 G15 G16 G46 G50 G61 G65 H2 H3 H5 H6 H11 H13 H16 H63 J2 J5 J6 J68 J71 K45 K46 L6 M1 M4 N1 N2 N3 N7 N9 N11 N12 P2 P3 P4 P62 U1 U2 U3 U8 U9 V1 V2 V62 W7 W10 W11 W12; UC2 1; UC6 1; UC7 1; UE1 10 23 24 32 34 41 63 70 71 89 91 96 97; UE2 1; UM1 A1 A2 A7 A8 A9 A10 A11 A12 A13 A14 B1 B7 B8 B9 B10 B11 B12 B13 B14 C1 C3 C5 C7 C8 C9 C10 C11 C12 C13 C14 D1 D2 D3 D4 D12 D13 D14 E1 E2 E3 E5 E8 E12 E13 E14 F1 F2 F3 F12 F13 F14 G1 G2 G3 G10 G12 G13 G14 H1 H2 H3 H12 H13 H14 J1 J2 J3 J12 J13 J14 K1 K2 K3 K6 K7 K10 K12 K13 K14 L1 L2 L3 L12 L13 L14 M1 M2 M3 M7 M8 M9 M10 M11 M12 M13 M14 N1 N3 N6 N7 N8 N9 N10 N11 N12 N13 N14 P1 P2 P7 P8 P9 P10 P11 P12 P13 P14; UM2 1; UX1 4 5 6 7 10 11 12 13 15 25 26 28 30 31; YC1 2 4; YC3 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 582 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 4366 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 23 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 117 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 15
  TOP w0.254: UC2.4 103.07,118.53 CC90.1 103.05,118.52 102.03,118.52 RC9.2 v2(101.27,118.53)
  BOTTOM w0.254: PRM09.1 97.25,127.53 99.22,125.56 99.22,120.58 v1(100.01,119.79) v2(101.27,118.53)
1.0V_VCCST_EN: length 4.8
  TOP w0.102: v1(152.53,69.27) DZ5.2 152.03,67.79 RZ1.2 CZ1.1 149.85,67.01 UZ1.3
1.2V_VTT_PWRGD: length 70.1
  TOP w0.102: v1(144.59,107.83) RC106.1
  TOP w0.254: RC106.1 v2(143.82,106.78)
  IN1 w0.254: v2(143.82,106.78) 143.82,109.95 142.59,111.18 142.59,116.07 v2(141.51,117.15)
  IN2 w0.254: v2(141.51,117.15) 141.35,116.99 131.88,116.99 120.25,128.62 109.34,128.62 108.87,129.09 104.43,129.09 104.23,129.29 102.07,129.29 100.86,130.5 v2(92.97,130.5)
  BOTTOM w0.203: PUM01.10 94.29,130.89 94.25,130.86 93.3,130.86 92.97,130.53 v2(92.97,130.5) 92.77,130.3 PRM06.2
2.5V_VIN: length 2
  BOTTOM w0.102: v1(48.57,28.05) 48.57,27.54 49.26,26.86 49.79,26.86
3.3V_TS_EN: length 117.3
  TOP w0.102: R72.1 211.06,46.1 v2(211.46,45.69) 212,45.69 212.31,45.38 U3.4 ; v1(119.57,62.14) 119.22,62.48 v2(119.22,62.67)
  IN1 w0.127: v2(211.46,45.69) 209.72,47.43 208.77,47.43 208.06,46.72 208.06,45.76 200.62,38.31 192.12,38.31 191.48,38.95 187.57,38.95 186.78,38.16 178.57,38.16 178.27,37.85 174.97,37.85 174.31,38.51 172.84,38.51 169.93,41.42 160.17,41.42 158.53,43.07 154.62,43.07 151.65,46.04 151.65,46.35 149.73,48.27 149.73,56.11 148.59,57.25 143.32,57.25 140.88,59.69 136.56,59.69 136.14,60.1 120.2,60.1 119.54,60.76 119.54,62.36 v2(119.22,62.67)
  BOTTOM w0.076: UC1.AP5 118.98,62.43 v2(119.22,62.67)
3V_FB: length 6
  BOTTOM w0.102: v1(114.31,140.62) 114.18,140.75 112.59,140.75 PR308.1
  BOTTOM w0.254: PR308.1 PC315.1 112.1,139.4 PR307.2 111.22,139.39 PU301.13
3V_SN: length 1.8
  TOP w0.102: PR305.2 v1(104.92,138.04)
3V_VIN: length 0.7
  TOP w0.102: v2(104.24,140.9) v1(104.24,140.22)
  vias: v2(104.94,140.9)
5V_FB: length 6.4
  BOTTOM w0.102: PR511.1 162.74,139.61 163.58,139.61 163.74,139.76 v1(163.74,140.95)
  BOTTOM w0.254: PU501.13 160.81,137.85 161.28,138.32 PR510.2 161.41,138.31 PC517.1 PR511.1
5V_SN: length 1.8
  TOP w0.102: PR505.2 v1(158.63,136.52)
5V_VIN:
  vias: v1(152.32,138.77) v2(151.42,140.52) v2(151.42,139.89) v2(152,139.86) v2(152.05,141.16) v2(152.05,140.52) v2(154.59,139.12) v2(155.23,139.12)
+0.6V_DDR_VTT: length 141.6
  TOP w1.016: 57.34,46.6 58.1,46.6 59.28,47.77 63.31,47.77 63.37,47.83 64.95,47.83 65.05,47.93 68.07,47.93 68.58,47.42 68.58,46.66
  TOP w1.524: 98.84,129.73 98.84,125.34 97.76,124.26 81.06,124.26 79.28,126.04 79.28,129.98 78.14,131.12 73.44,131.12 71.43,129.12 v4(68.61,129.12) 64.96,129.12 55.66,119.82 55.66,82.99 55.66,70.01 55.56,69.91 55.56,67.61 55.66,67.51 55.66,52.98 55.76,52.89 55.69,52.82 55.76,52.76
  BOTTOM w0.305: v2(72.81,46.11) 72.69,45.99 JDIMM1.258 ; v2(56.96,46.73) 56.96,46.31 57.28,45.99 JDIMM2.258
+0.6VSP: length 0.7
  TOP w0.102: v2(99.98,134.23) v4(100.71,134.23)
  vias: v2(99.98,133.6)
+1.0V_AMPHYPLL: length 11.9
  TOP w0.508: v2(142.62,60.89) 141.52,60.89 139.1,63.3 137,63.3 136.05,64.26 136.05,65.02 134.91,66.16
  BOTTOM w0.508: v2(142.62,60.89) 143.65,59.86 RC169.2
  vias: v1(133.43,66.63) v2(130.92,67.23)
+1.0V_APLL: length 3.1
  TOP w0.127: v2(127.32,67.34) 127.46,67.34 v1(127.77,67.65)
  TOP w0.254: v2(127.32,67.34) 127.09,67.57 CC82.1 L1.2
  BOTTOM w0.254: v2(127.32,67.34) 126.92,67.66 UC1.V15
+1.0V_CLK2: length 21.8
  TOP w0.381: v2(147.45,70.65) 147.41,70.69 v1(147.41,71.26) 147.41,71.29 148.16,72.04 CC76.1 RC170.2
  IN1 w0.254: v2(147.45,70.65) 147.38,70.65 146.41,69.69 143.04,69.69 140.97,71.75 136.43,71.75 135.1,70.42 132.59,70.42 v2(132.14,69.98)
  BOTTOM w0.254: v2(132.14,69.98) 132.05,70.07 131.36,70.07 UC1.K19
+1.0V_CLK4: length 26.5
  IN1 w0.254: v2(147.44,70.02) 147.28,70.02 146.57,69.3 142.62,69.3 140.56,71.37 136.59,71.37 135.49,70.27 135.49,69.49 134.64,68.64 133.19,68.64 132.46,69.37 131.87,69.37 131.28,69.97 v2(129.85,69.97)
  BOTTOM w0.102: v1(147.57,72.73) 147.96,72.34 RC173.2
  BOTTOM w0.254: v2(129.85,69.97) 129.85,70.55 UC1.N20
  BOTTOM w0.305: v2(147.44,70.02) 147.19,70.02 146.92,70.29 146.92,71.04 CC84.1 146.94,71.4 RC173.2
+1.0V_CLK5: length 30.5
  TOP w0.254: CC77.1 141.19,76.32 140.85,76.67 140.85,79.96 v2(139.99,80.82)
  TOP w0.305: 144.56,75.56 v1(144.56,74.77) v2(143.57,73.78) ; 144.56,75.56 146.59,75.56 146.78,75.75 RC171.2 ; 144.56,75.56 144.37,75.75 CC77.1
  IN1 w0.254: v2(143.57,73.78) 142.59,72.8 138.25,72.8 137.82,73.23 133.95,73.23 133.95,73.23 132.13,73.23 v2(131.1,72.19)
  BOTTOM w0.254: UC1.L19 130.64,70.69 130.64,71.73 v2(131.1,72.19)
  BOTTOM w0.508: RC76.2 139.78,81.02 v2(139.99,80.82)
+1.0V_MPHYGT:
  vias: v2(128.29,67.34) v2(128.99,68.09) v2(129.06,68.71) v2(129.83,68) v2(129.89,67.35) v2(138.46,58.29) v2(138.97,58.67) v2(139.07,58.05) v2(139.62,58.68) v2(139.66,58.05) v4(135.85,59.93)
+1.0V_PRIM: length 150.6
  TOP w0.203: 50.48,75.91 50.48,75.53 50.19,75.23 UE1.95
  TOP w0.381: v2(128.51,59.4) CC87.1 129.31,59.39 CC72.1 131.04,59.39 v2(131.05,59.39)
  TOP w0.508: v2(52.06,79.15) CE17.1 51.87,78.26 51.18,78.26 50.48,77.56 50.48,75.91 ; v2(149.48,69.56) 149.93,70 RC170.1
  IN1 w0.203: v2(84.41,42.96) 85.18,42.96 90.29,48.06 92.55,48.06 93.82,49.33 96.85,49.33 99.22,51.7 99.22,53.54 101.12,55.44 101.12,57.68 102.43,58.99 104.55,58.99 107.16,61.6 108.89,61.6 109.54,62.25 111,62.25 114.65,65.91 114.65,67.81 116.37,69.53 118.32,69.53 118.53,69.73 118.53,69.88 119.13,70.48 120.68,70.48 120.98,70.78 120.98,70.83 v2(121.47,71.32)
  BOTTOM w0.203: v2(128.51,59.4) 128.51,59.44 128.39,59.56 UC1.T1 ; UC1.A10 136.42,65.11 v2(136.81,65.11) ; v2(137.65,67.36) 137.61,67.4 UC1.A14
  BOTTOM w0.254: 128.19,72.11 127.93,72.37 124.53,72.37 123.95,71.78 v2(123.95,71.33) ; 128.19,72.11 v2(129.86,72.11) UC1.L21 ; 128.19,72.11 128.19,71.4 UC1.T20 ; UC1.AF21 123.66,71.62 v2(123.95,71.33) ; v2(131.05,59.39) 131.07,59.42 131.07,59.89 UC1.L1 ; UC1.AF18 123.61,69.67 v2(123.95,70.01) ; UC1.V20 v2(127.35,71.28) 127.45,71.28 UC1.T20 ; v2(123.95,71.33) 123.92,71.3 123.89,71.3 UC1.AF20 ; UC1.AB19 125.53,70.03 125.62,70.03 v2(125.62,70.02) 125.72,70.02 UC1.Y18 v2(125.62,69.32) UC1.AB17 ; v2(125.61,71.29) 125.56,71.29 UC1.AB20 ; UC1.K17 131.06,69.02 v2(130.73,69.35) ; v2(121.47,71.32) 121.12,70.97 UC1.AK20 ; UC1.N18 129.43,69.63 v2(129.06,69.33) ; UC1.T20 128.08,70.65 v2(128.23,70.65) ; UC1.AF19 123.88,70.64 v2(123.93,70.64) ; v2(127.35,70.64) 127.67,70.32 UC1.T19 128.04,70.04 v2(128.18,70.04) 128.23,70.04 UC1.P18 128.52,69.67 v2(128.22,69.37) ; v2(126.5,71.87) 126.62,71.87 126.87,71.62 UC1.V21
  BOTTOM w0.508: v2(84.41,42.96) 83.52,42.06 61.92,42.06 59.85,44.13 57.19,44.13 55.72,45.6 55.72,73.66 52.06,77.32 v2(52.06,79.15)
  vias: v2(148.15,74.19) v2(148.54,63.98) v2(148.54,63.32) v2(148.54,62.59) v2(148.73,74.19) v2(148.85,69.56) v2(149.02,63.65) v2(149.02,62.97) v2(149.01,62.19) v4(155.66,63.3)
+1.0V_VCCST: length 111.2
  TOP w0.254: RC104.2 144.22,99.27 141.6,99.27 141.11,98.78 141.11,97.22 v2(141.6,96.73) ; v2(155.23,120.44) 154.99,120.44 PCZ24.1 PRZ40.1 PRZ41.1 PRZ42.1 PRZ43.1
  TOP w0.508: 143.83,69.43 143.37,69.9 138.38,69.9 137.61,69.13 v2(137.38,69.13) 137.33,69.13 v4(136.02,70.45) 134.73,70.45
  IN1 w0.254: v2(155.23,120.44) 155.23,119.86 153.35,117.99 150.45,117.99 148.25,115.79 146.47,115.79 145.22,114.54 145.22,112.07 146.11,111.18 146.11,109.99 144.66,108.54 144.66,104.73 147.67,101.72 147.67,97.85 146.85,97.85 146.17,98.52 142.79,98.52 141.6,97.33 v2(141.6,96.73) 142.94,95.39 v2(142.94,95.26) v2(142.94,94.32)
  IN1 w0.381: 147.67,97.85 153.17,97.85 153.55,97.47 153.55,89.78 155.41,87.93 155.41,84.49 151.53,80.62 151.53,75.67 149.46,73.6 145.94,73.6 144.94,72.6 144.04,72.6 143.26,71.81 143.26,71.27 143.63,70.9 v2(144.21,70.9)
  BOTTOM w0.254: RC152.1 142.45,95.75 v2(142.94,95.26) ; UC1.K20 v2(131.63,70.97) 131.63,70.97 131.63,71.1 UC1.K21 ; RC111.1 141.18,94.07 RC112.1 141.77,93.47 142.53,93.47 142.94,93.88 v2(142.94,94.32)
  BOTTOM w0.381: v2(141.6,96.73) 141.6,97.43 RC138.2 RC154.1
+1.0V_VCCST_C: length 1.5
  TOP w0.127: 144.69,66.94 v1(143.16,66.94)
+1.0V_VCCSTG: length 90.8
  TOP w0.254: CC42.1 144.86,73.15 v2(144.55,73.15) ; v2(141.61,98.45) 141.72,98.56 RC141.2 148.23,98.56 149.59,97.2 v4(152.08,97.2) v2(152.95,97.2)
  TOP w0.381: RZ4.1 147.92,69.38 v2(147.44,69.38)
  IN1 w0.254: v2(141.61,98.45) 141.12,97.96 141.12,94.18 142.88,92.42 v2(142.94,92.42) ; v2(132.81,70.92) 132.81,71.12 133.07,71.37 134.86,71.37 135.89,72.4 v2(137.34,72.4) 141.24,72.4 141.77,71.87 142.67,71.87 ; v2(145.51,60.73) 147.44,62.66 v2(147.44,69.38) 147.86,69.38 148,69.52 148,70.88 147.64,71.24 146.13,71.24 145.19,70.3 143.39,70.3 142.67,71.01 142.67,71.87 ; 142.67,71.87 143.95,73.15 v2(144.55,73.15) 144.59,73.15 146.11,74.68 149.07,74.68 151.02,76.63 151.02,80.83 154.24,84.04 154.24,88.38 153.04,89.57 153.04,97.11 v2(152.95,97.2)
  BOTTOM w0.203: v2(137.34,72.4) 137.29,72.35 UC1.A22
  BOTTOM w0.254: UC1.G20 132.81,70.77 v2(132.81,70.92) ; RC113.1 141.78,98.63 v2(141.61,98.45) ; RC142.2 142.2,90.46 143.09,90.46 143.63,91 143.63,92.11 143.32,92.42 v2(142.94,92.42) 142.8,92.56 RC140.2
+1.0V_XDP: length 3.6
  BOTTOM w0.381: RC149.2 144.19,61.27 v1(143.47,61.98) 142.36,63.09 RC143.1
+1.0VS_VCCIO: length 21.1
  TOP w0.254: RC4.1 133,88.43 v2(132.81,88.25)
  IN1 w0.381: v2(132.81,88.25) 132.38,88.25 131.96,88.67 131.96,89.31 131.46,89.8 130.67,89.8 130.3,89.43 130.3,88.91 129.82,88.43 124.53,88.43 122.99,86.88 121.11,86.88 120.53,86.3 120.53,85.24 119.97,84.69 v2(119.97,83.83)
  BOTTOM w0.254: v2(121.47,82.83) UC1.AL42 120.74,82.83 UC1.AM42 119.97,83.6 v2(119.97,83.83) ; UC1.AM30 119.95,77.27 v2(119.96,77.34)
  vias: v2(117.19,58.54) v2(117.18,57.94) v2(117.18,57.36) v2(117.83,58.54) v2(117.83,57.96) v2(121.7,76.71) v2(121.7,76.12) v4(143.85,45.3)
+1.2V_DDR: length 120.8
  TOP w0.102: v2(84.49,118.84) v4(85.2,118.84)
  TOP w0.254: CC33.1 117.82,83.24 117.1,83.24 v2(116.67,83.67)
  TOP w0.305: v2(60.02,55.45) 60,55.44 CD56.1
  TOP w0.381: CC1.1 103.38,116.74 103.87,117.23 UC2.5 ; CD54.1 v2(60.36,62.03)
  TOP w0.508: CD47.1 68.56,83.13 68.19,82.75 v2(67.84,82.75) ; v2(67.74,84.74) 67.71,84.77 CD48.1 ; CC40.1 117.66,73.94 v2(117.4,73.68) ; v2(63.86,92.89) 63.86,92.7 64.37,92.19 65.28,92.19 66.1,93.01 CD55.1 ; CD53.1 59.9,109.79 v2(59.92,109.81) ; CD23.1 73.49,109.79 v2(73.51,109.76) ; v2(57.03,81.78) 57.04,81.8 RD24.1 ; v2(105.63,98.39) 105.69,98.45 CC39.1 105.67,99.17 CC35.1 ; CC29.1 CC30.1 103.67,71.64 v2(103.68,71.62) ; RD23.1 69.41,78.93 v2(69.38,78.89) ; v2(77.25,50.3) 77.33,50.22 CD24.1 ; CC31.1 CC26.1 v2(104.68,80.87) ; CD16.1 69.42,82.86 v2(69.38,82.82) ; v2(69.46,84.76) 69.47,84.77 CD17.1 CD18.1 ; CD42.1 56.92,84.51 v2(56.9,84.49) ; CC1.1 v2(103.08,115.99) ; CD12.1 CD14.1 77.68,77.07 v2(77.25,76.63) ; CD26.1 72.8,76.64 v2(72.81,76.63) ; CC38.1 105.18,94.61 CC28.1 105.19,93.78 v2(105.25,93.73) ; v2(67.65,60.96) 67.58,60.89 CD49.1 ; CD22.1 77.5,92.51 v2(77.08,92.94) ; v2(72.88,66.18) 72.8,66.1 CD25.1 ; v2(67.73,72.95) 67.73,72.55 CD43.1 68.03,72.14 RD10.1 ; CC32.1 CC43.1 105.57,91.54 v2(105.6,91.57) ; CD20.1 77.37,79.43 v2(77.24,79.3) ; v2(80.64,80.69) 80.63,80.7 CD44.1 ; v2(105.61,84.62) 105.57,84.58 CC27.1 105.56,83.94 CC36.1 ; CD13.1 80.56,82.99 v2(80.63,83.05) ; v2(56.9,87.75) 57.6,87.75 CD51.1 ; v2(67.96,78.88) 68.06,78.88 68.56,79.38 CD45.1 ; CD11.1 77.13,60.89 v2(77.13,60.89) ; v2(73.49,99.14) 73.47,99.12 CD50.1 ; v2(56.9,82.99) 56.9,82.99 CD41.1 ; v2(73.57,55.99) 73.25,55.68 CD21.1 ; CD15.1 v2(69.38,80.83) ; CC34.1 104.06,87.89 CC37.1 104.05,88.54 v2(104.14,88.63) ; CD19.1 72.35,72.25 v2(72.75,71.86) ; CD46.1 68.56,81.35 68.02,80.81 v2(67.82,80.81) ; RD20.1 58.47,72.2 57.97,72.7 v2(56.93,72.7) ; RD7.1 v2(60.79,88.44) ; CD52.1 v2(60.05,98.61)
  IN1 w0.254: v2(120.66,71.97) 120.66,73.8 120.27,74.19 119.64,74.19 119.57,74.13 117.85,74.13 v2(117.4,73.68) ; v2(117.31,80.08) 116.84,80.08 116.19,80.73 116.19,83.26 116.6,83.67 v2(116.67,83.67)
  BOTTOM w0.152: UC1.BB41 113.42,82.38 ; v2(113.02,72.22) 113.23,72.43 114.08,72.43 114.1,72.44 UC1.BB23
  BOTTOM w0.178: UC1.BB47 113.72,86.03 113.38,86.03 v2(113.31,85.99) ; UC1.BB32 114.13,77.42 114.11,77.41 113.34,77.41 113.22,77.3 v2(112.3,77.3)
  BOTTOM w0.203: v2(113.21,88.33) 113.37,88.49 UC1.BB51
  BOTTOM w0.254: UC1.AU28 v2(117.35,76.45) ; v2(112.5,82.45) 112.57,82.38 113.42,82.38 ; UC1.AU42 117.03,83.3 v2(116.67,83.67) ; UC1.AU23 v2(117.4,73.68) ; UC1.AL23 120.76,72.06 v2(120.66,71.97) ; UC1.AM40 v2(120.03,82.79) ; UC1.AU35 v2(117.31,80.08)
  BOTTOM w0.305: v2(60.05,98.61) 59.58,98.61 59.2,98.99 JDIMM2.54 ; JDIMM1.199 77.27,60.74 v2(77.13,60.89) ; v2(67.65,60.96) 67.43,60.74 JDIMM2.199 ; JDIMM2.75 65.5,93.74 65.16,93.4 64.37,93.4 v2(63.86,92.89) ; JDIMM1.178 72.69,65.99 v2(72.88,66.18) ; v2(56.9,87.75) 56.9,88.19 57.2,88.49 JDIMM2.96 ; JDIMM1.33 78.23,104.24 77.77,104.7 76.18,104.7 75.8,104.31 v2(75.8,104.14) ; JDIMM1.112 69.74,84.49 ; v2(73.51,109.76) 73.24,109.49 JDIMM1.12 ; v2(69.06,88.17) 69.39,88.49 JDIMM1.96 ; v2(64.59,49.99) 64.84,50.24 JDIMM2.241 ; JDIMM1.241 77.31,50.24 v2(77.25,50.3) ; JDIMM2.111 v2(67.74,84.74) ; JDIMM1.75 77.38,93.74 77.08,93.43 v2(77.08,92.94) ; JDIMM2.130 v2(56.9,79.99) ; v2(64.62,104.37) 64.75,104.24 JDIMM2.33 ; JDIMM1.220 73.07,55.49 v2(73.57,55.99) ; v2(60.05,66.01) 59.29,66.01 59.26,65.99 JDIMM2.178 ; v2(59.92,109.81) 59.6,109.49 JDIMM2.12 ; JDIMM2.220 59.98,55.49 v2(60.02,55.45) ; JDIMM2.142 v2(57.02,76.99) ; v2(73.49,99.14) 73.49,99.28 73.19,99.59 72.4,99.59 71.81,98.99 JDIMM1.54
  vias: v2(56.9,78.49) v2(56.96,73.49) v2(60.06,70.49) v2(63.1,74.49) v2(63.1,69.7) v2(74.31,75.05) v2(74.49,70.83) v2(75.81,83.52) v2(75.84,75.05) v2(75.76,69.65) v2(76.02,70.83) v2(77.32,71.86) v2(80.04,118.84) v2(80.04,118.25) v2(80.68,118.84) v2(80.68,118.25) v2(81.31,118.84) v2(81.31,118.25) v2(81.95,118.84) v2(81.95,118.25) v2(82.58,118.84) v2(82.58,118.25) v2(83.22,118.84) v2(83.22,118.25) v2(83.85,118.84) v2(83.85,118.25) v2(84.49,118.25)
+1.2VP: length 35.1
  TOP w0.762: 96.64,134.74 96.64,130.64 95.22,129.22 93.86,129.22 92.34,127.69 90.08,127.69 87.47,130.3
  IN1 w0.254: v2(100.43,129.76) 100.15,129.48 90.12,129.48 88.77,130.83 87.19,130.83 v2(86.9,131.12)
  BOTTOM w0.203: PRM10.2 PCM17.2 98.51,130.7 PCM18.1 97.38,131.57 96.97,131.97 PUM01.5
  BOTTOM w0.254: v2(100.43,129.76) 99.5,130.69 PRM10.2
  vias: v2(84.74,132.39) v2(85,131.76) v2(85,131.12) v2(85.38,132.39) v2(85.63,131.76) v2(85.63,131.12) v2(86.01,132.39) v2(86.27,131.76) v2(86.27,131.12) v2(86.65,132.39) v2(86.9,131.76) v2(87.28,132.39) v2(95.92,135.25) v2(96.36,135.63) v4(85.96,130.56)
+1.8V_AVDD: length 10.7
  TOP w0.102: RA5.2 22.13,8.06 v1(21.76,8.43)
  TOP w0.203: 28.11,8.44 28.78,9.11 UA1.40
  TOP w0.381: 28.11,8.44 27.64,7.97 27.64,7.48 27.47,7.3 25.05,7.3 24.42,7.93 CA12.2 23.66,7.3 22.56,7.3 22.42,7.44 RA5.2
+1.8V_CPVDD: length 17.9
  TOP w0.127: CA13.2 25.97,5.82 26.12,5.67 26.12,5.27 v1(26.35,5.04)
  TOP w0.203: v2(26.35,10.58) 26.35,11.01 26.39,11.05 UA1.36
  TOP w0.381: v2(26.67,6.3) 26.63,6.27 CA13.2 25.08,6.27 CA14.1 24.06,6.49 RA6.2
  IN1 w0.381: v2(26.35,10.58) 26.35,10.71 27.62,11.98 30.04,11.98 30.67,11.35 30.67,10.77 29.88,9.98 29.88,7.82 28.36,6.3 v2(26.67,6.3)
+1.8V_EMMC: length 47.8
  TOP w0.102: v4(155.79,33.88) CM3.1
  TOP w0.203: UM1.N4 UM1.M4 149.11,35.61 149.11,35.56 v2(149.08,35.56) ; v2(152.88,35.11) 152.88,35.11 UM1.P3 ; v2(146.03,37.12) UM1.C6 ; 152.55,36.11 UM1.P5
  TOP w0.508: RM2.2 155.79,37 CM4.1 CM3.1 v2(152.88,35.11) 152.88,35.87 152.64,36.11 152.55,36.11 152.55,40.38 151.82,41.11 139.14,41.11 138.13,40.09
  IN1 w0.508: v2(152.88,35.11) 150.15,35.11 149.7,35.56 v2(149.08,35.56) 149.05,35.56 149.05,35.37 148.68,35.01 145.98,35.01 145.39,35.6 145.39,36.82 145.7,37.12 v2(146.03,37.12)
  IN2 w0.508: v2(149.89,33.33) 150.13,33.57 150.13,33.94 151.37,35.17 152.82,35.17 v2(152.88,35.11)
  BOTTOM w0.508: v2(149.89,33.33) 149.9,33.33 150.28,33.7 RM3.1
+1.8V_PRIM: length 259.3
  TOP w0.508: v2(150.72,45.97) 152.88,43.81 152.88,41.21 155.36,38.73 RM2.1 157.34,37.51 157.34,33.85 155.51,32.02 150.24,32.02 149.19,33.07 v2(147.42,33.07) ; v2(44.1,38.03) 43.34,37.27 43.34,30.16 v4(42.57,29.38) 40.42,27.24 QA1.1 ; RE66.1 43.06,53.82 42.71,53.47 v2(42.71,50.73)
  TOP w1.016: 43.6,50.35 43.98,49.97 43.98,46.13 45.68,44.43 50.91,44.43 53.12,42.22 57.25,42.22
  IN1 w0.508: 42.07,50.67 42.07,50.85 36.49,56.43 36.49,60 35.63,60.85 35.63,69.11 34.2,70.54 34.2,75.31 31.06,78.44 31.06,83.28 33.49,85.71 v2(33.49,123.53) ; v2(42.71,50.03) 42.71,39.43 v2(44.1,38.03)
  IN1 w1.016: 126.02,54.41 125.58,54.85 124.35,54.85 123.62,55.58 123.62,55.6 122.65,55.6 122.63,55.61 120.75,55.61 118.56,53.42 109.44,53.42 108.27,52.26 103.62,52.26 ; 103.16,51.75 102.17,50.76 102.17,48.52 100.63,46.99 100.16,46.99 96.99,43.81 93.99,43.81 93.74,43.56 92.01,43.56 88.87,40.42 67.36,40.42 67.08,40.7 59.82,40.7 59.23,41.29
  IN1 w2.032: 138.49,53.69 135.51,53.69 132.43,50.6 127.99,50.6 127.16,51.43
  BOTTOM w0.203: UC1.AA1 125.69,59.87 125.69,59.07 v2(125.72,59.05)
  BOTTOM w0.254: RM27.1 v2(147.42,33.07) ; v2(121.64,67.27) 121.53,67.27 121.07,67.72 UC1.AK15 ; v2(123.98,68.04) UC1.AF16
  BOTTOM w0.508: v2(33.49,123.53) 33.33,123.68 R23.1
  vias: v2(58.33,42.54) v2(58.77,42.1) v2(103.09,53.72) v2(126.18,53.49) v2(126.18,52.83) v2(126.78,52.83) v2(140.43,52.76) v2(141.07,52.76) v2(141.07,52.18) v2(141.39,51.62)
+1.8VALW_EC: length 6.5
  TOP w0.102: RE66.2 42.86,59.4 42.38,58.91 v4(42.38,56.75)
  TOP w0.203: UE1.54 43.6,60.18
  TOP w0.381: RE66.2 43.07,59.41 CE15.1 44.13,59.65 43.6,60.18
+1.8VALWP: length 23.1
  TOP w0.102: PC1804.1 v4(156.93,47.86)
  IN1 w0.254: v2(154.96,47.16) 154.48,47.64 154.48,49.47 154.91,49.91 162.91,49.91 163.69,49.13 170.25,49.13 v2(170.79,48.59)
  BOTTOM w0.254: v2(170.79,48.59) 170.79,48.87 170.53,49.13 PC1807.1 PR1807.1
  vias: v2(155.55,47.16)
+1VALWP: length 17.9
  IN1 w0.254: v2(155.39,53.65) 155.8,53.24 155.8,52 156.24,51.56 168.75,51.56 169.53,50.78 v2(169.53,50.32)
  BOTTOM w0.254: PRH08.2 169.52,50.33 v2(169.53,50.32) 169.75,50.1 PCH14.1
  vias: v2(154.22,55.74) v2(154.22,55.05) v2(154.22,54.35) v2(154.8,55.74) v2(154.8,55.05) v2(154.8,54.35) v2(154.8,53.65) v2(155.39,55.74) v2(155.39,55.05) v2(155.39,54.35) v4(153.65,54.11)
+2.5V_MEM: length 38.7
  TOP w1.016: 68.37,38.62 78,38.62 80.87,41.49 80.87,44.43 ; 68.37,38.62 52.88,38.62 ; 68.37,38.62 68.46,38.7 68.46,45.14
  vias: v2(67.69,46.22) v2(68.07,45.77) v2(80.65,45.52) v2(81.28,45.52) v4(81.8,44.86)
+2.5VP: length 0.8
  TOP w0.102: v2(53.06,35.8) v4(53.06,34.98)
  vias: v2(52.68,36.25)
+3.3V_ALW_DSW: length 164.8
  TOP w0.254: v2(122.29,58.3) 122.29,58.48 RC163.2 121.57,60.83 122.18,61.43 122.18,63.6 120.35,65.43 120.35,66.23 RC85.1 121.12,66.99 121.12,67.75 121.04,67.83 121.04,68.26 121.43,68.65 v2(121.49,68.65) ; v2(111.97,56.87) 112.08,56.76 112.08,56.31 107.92,52.15 107.92,50.8 106.45,49.32 v2(106.45,48.94) ; RE12.1 v2(29.63,75.88) ; Q15.1 50.12,47.07 51.04,46.16 51.17,46.16 52.16,45.17 53.88,45.17 v2(54.87,46.16) ; v2(98.93,44.08) 99.03,43.98 102.36,43.98 102.71,44.33 102.71,46.88 v2(103.2,47.37) 103.2,48.35 104.07,49.22 104.07,50.06 103.68,50.45 103.68,51.21 v1(103.23,51.67) RC89.2 RC90.2
  IN1 w0.254: v2(111.97,56.87) 112.48,57.38 114.29,57.38 115.35,56.32 119.04,56.32 121.02,58.3 v2(122.29,58.3) ; v2(98.93,44.08) 98.33,44.08 97.3,43.05 94.31,43.05 94.05,42.8 92.43,42.8 89.29,39.66 67.05,39.66 66.77,39.94 59.26,39.94 54.87,44.33 v2(54.87,46.16)
  IN2 w0.254: v2(121.49,68.65) 121.96,68.65 122.66,69.34 v2(123.96,69.34) ; v2(54.87,46.16) 54.75,46.29 54.75,53.68 53.6,54.83 53.6,58.12 54.16,58.68 54.16,61.25 52.26,63.15 52.26,63.89 47.63,68.52 44.52,68.52 37.19,75.85 35.37,75.85 v2(35.24,75.98)
  BOTTOM w0.254: v2(103.2,47.37) 104.04,47.37 105.62,48.94 v2(106.45,48.94) ; UC1.AJ17 121.89,68.96 121.58,68.65 v2(121.49,68.65) ; RC93.1 99.48,42.98 98.93,43.53 v2(98.93,44.08) ; UC1.AD18 124.37,69.67 v2(123.96,69.34) 124.39,69.02 UC1.AD17 ; v2(29.63,75.88) 30.44,76.69 34.53,76.69 v2(35.24,75.98)
+3.3V_HDA: length 3.1
  TOP w0.254: v2(121.47,70.67) 121.54,70.67 122.09,70.12 CC61.1 122.25,69.99 122.96,69.28 L2.2
  BOTTOM w0.254: v2(121.47,70.67) 121.47,70.67 121.82,70.32 UC1.AJ19
+3.3V_SPI: length 90.1
  TOP w0.254: RX7.1 v2(115.1,37.66) ; v2(116.11,54.79) 116.11,53.95 123.07,46.99 123.07,46.62 v2(123.08,46.6) 123.08,46.54 123.5,46.54 124.62,45.42 125.81,45.42 126.63,44.61 126.63,43.09 126.73,42.98 126.73,41.13 v1(126.98,40.88) 127.03,40.83 127.17,40.83 127.79,40.2 127.79,39.62 127.22,39.05 RC17.2 127.68,38.48 127.92,38.24 v2(127.92,37.85)
  IN1 w0.254: v2(109.15,56.64) 109.41,56.38 112.33,56.38 112.68,56.73 v2(112.68,56.9) 114,56.9 v2(116.11,54.79) 118.1,54.79 120.19,56.88 122.81,56.88 123.42,57.49 125.2,57.49 125.8,56.89 129.46,56.89 130.57,58 132.33,58 v2(132.44,57.89) ; v2(115.1,37.66) 115.68,37.08 125.83,37.08 126.55,37.8 127.87,37.8 v2(127.92,37.85)
  IN2 w0.254: v2(112.68,56.9) 112.81,57.02 113.38,57.02 114.72,58.35 114.72,59.56 116.18,61.02 116.19,61.02 116.91,61.73 117.36,61.73 117.7,62.07 117.7,62.94 117.95,63.19 118.31,63.19 118.68,63.56 118.68,64.41 121.05,66.78 121.05,67.57 121.51,68.03 v2(121.52,68.03)
  BOTTOM w0.254: UC3.8 121.73,45.31 121.55,45.49 121.55,45.81 CC3.1 122.98,46.7 v2(123.08,46.6) ; UC1.AJ16 121.86,68.37 v2(121.52,68.03) ; v2(132.44,57.89) 132.77,57.89 133.48,57.18 133.48,55.74 133.77,55.45 RX4.1 ; v2(112.68,56.9) 112.68,56.8 112.45,56.56 RC19.1 ; RC20.1 108.86,56.36 v2(109.15,56.64)
  BOTTOM w0.305: v2(116.11,54.79) 116.08,54.82 RC18.1 ; RC139.1 112.07,56.27 112.09,56.29 RC19.1
+3.3V_WLAN: length 1.4
  TOP w0.102: v2(69.36,120.83) v4(69.36,119.38)
  vias: v2(69.36,121.41) v2(69.55,139.95) v2(69.55,139.37) v2(69.99,121.41) v2(69.99,120.83) v2(70.18,139.95) v2(70.18,139.37) v4(69.3,138.11) v4(69.86,122.11)
+3V_DVDD: length 8.2
  IN2 w0.508: v2(34.26,14.79) 35.09,13.97 35.09,10.35 36.61,8.82 v2(37.88,8.82)
  vias: v1(34.21,15.62)
+3V_EMMC: length 33.5
  TOP w0.203: UM1.F5 147.02,36.59 v2(146.99,36.61) UM1.E6 ; v2(147.96,39.08) 148.31,39.08 148.52,38.88 UM1.J10 UM1.K9
  TOP w0.508: UM2.5 149.29,28.52 CM7.1 149.17,28.39 v4(147.75,28.39) 147.28,28.86 147.28,31.89 v2(147.66,32.27)
  IN1 w0.508: v2(146.99,36.61) 146.99,36.64 147.71,37.36 148.12,37.36 148.48,37.72 148.48,38.56 v2(147.96,39.08) 149.61,39.08 150.59,38.1 150.59,36.44 151.04,36 152.89,36 153.64,35.25 153.64,34.5 153.13,33.99 149.21,33.99 147.66,32.44 v2(147.66,32.27)
  BOTTOM w0.508: v2(146.99,36.61) 146.78,36.41 CM2.1 ; RM1.2 146.1,39.59 CM1.1 146.47,38.48 147.07,39.08 v2(147.96,39.08)
+3VALW: length 436.5
  TOP w0.254: RC88.2 116.35,66.23 111.22,61.1 111.22,59.62 108.24,56.64 107.29,56.64 106.46,55.81 v2(105.63,55.81) ; v2(167.42,50.33) 167.42,50.7 PRH03.1
  TOP w0.381: v2(54.45,58.03) 53.63,58.03 53.08,58.59 R43.1 ; v2(53.58,62.83) RE15.2 52.9,62.82 RE25.1 ; CC12.1 124.56,39.19 UC6.5 ; RE58.1 RE57.1
  TOP w0.508: RE59.1 v2(48.66,93.42) ; R35.1 98.4,33.17 96.35,35.21 v2(96.35,41.21) 96.48,41.34 96.48,45.48 97.29,46.29 97.29,46.8 98.79,48.29 98.79,52.26 98,53.04 98,53.46 98,56.07 CC11.1 ; 34.47,55.96 28.59,55.96 26.07,58.48 26.07,60.76 26.45,61.15 27.2,61.15 29.34,63.28 v2(29.34,63.69) RE46.1 ; v2(169.58,44) 169.33,43.75 155.46,43.75 154.9,43.19 154.9,41.05 155.89,40.05 165.33,40.05 165.77,39.62 PR41.2 ; RE18.2 RE21.2 v2(29.63,76.77) ; v2(123.57,45.75) 124.41,44.92 125.59,44.92 126.12,44.38 126.12,42.88 126.22,42.77 126.22,41.77 125.09,40.63 125.09,39.72 CC12.1 ; v2(49.18,54.03) 49.36,54.03 50.35,53.04 R65.1 49.16,51.42 Q15.3 ; RE2.1 42.99,87.59 v2(42.58,87.18) ; CL9.1 25.1,103.36 26.96,105.21 v4(26.96,111.12) v2(18.2,119.88) ; RC163.1 121.57,57.59 v2(121.45,57.46) ; PRH05.1 v2(171.07,50.97) ; RC92.2 119.86,42.55 119.86,43.01 119.34,43.53 119.34,44.33 118.84,44.83 118.84,48.12 118.84,48.13 v2(118.84,48.38) ; R66.1 52.26,48.55 v2(51.55,49.26) ; v2(42.33,87.94) 40.04,87.94 38.9,86.8 RE40.2 ; PRB30.1 203.68,44.57 203.11,44 v2(202.73,44) 202.65,44 201.85,44.8 PRB42.2 ; RA11.2 27.15,21.55 v2(26.21,22.49) ; v2(42.22,88.68) 41.28,89.63 RE57.1 ; v2(79.66,147.32) 79.66,147.51 81.33,149.17 PR5.2 ; RE55.1 43.12,89.93 RE56.1 v2(43.07,89.09) ; PR1803.1 v2(164.75,50.08)
  IN1 w0.508: v2(213.52,56.19) 211.66,56.19 210.54,55.07 210.54,50.54 207.16,47.16 205.06,47.16 203.62,45.72 203.62,44.76 202.85,44 v2(202.73,44) 201.77,43.05 196.21,43.05 194.32,41.16 188.02,41.16 187.9,41.04 176.77,41.04 175.46,42.35 172.5,42.35 v2(170.85,44) ; v2(26.21,22.49) 26.21,22.93 28.48,25.2 33.62,25.2 34.82,26.41 41.47,26.41 41.79,26.73 46.64,26.73 v2(47.53,25.84) ; v2(146.97,99.94) 146.77,99.94 143.21,103.5 143.21,109.84 142.08,110.97 142.08,114.8 140.24,116.64 140.24,118.04 137.45,120.84 137.45,127.23 135.46,129.22 v2(118.4,129.22)
  IN2 w0.508: v2(29.63,76.77) 30.78,75.61 30.78,72.27 29.21,70.7 v2(29.21,70.19) 29.21,68.77 30.64,67.34 30.64,64.99 v2(29.34,63.69) ; v2(35.21,55.88) 35.37,56.03 39.82,56.03 39.91,55.94 40.94,55.94 43.08,53.79 48.05,53.79 48.29,54.03 v2(49.18,54.03) ; v2(91.86,128.7) 90.13,128.7 88.51,130.32 84.68,130.32 84.02,130.98 84.02,132.1 81.12,135 81.12,145.85 v2(79.66,147.32)
  BOTTOM w0.254: UX1.1 109.48,39.17 109.38,39.08 108.79,39.08 108.57,38.86 CX2.1
  BOTTOM w0.381: Q17.5 v2(18.2,119.88) Q17.2
  BOTTOM w0.508: PRM06.1 v2(91.86,128.7) ; JPWR1.4 224.2,59.63 222.67,58.1 220.44,58.1 218.54,56.19 v2(213.52,56.19) ; v2(108.57,37.15) CX1.1 CX2.1
  BOTTOM w1.016: 150.78,64.13 150.78,53.14 148.6,50.96 ; 26.07,99.69 31.09,99.69 41.5,89.28 ; 47.85,26.73 47.41,27.17 47.41,29.29 48.93,30.82 48.93,34.98 48.74,35.17
  BOTTOM w2.54: 58.2,123.63 58.2,121.6 54.25,117.65 54.25,115.79
  vias: v2(24.67,99.37) v2(25.18,99.69) v2(45.75,90.23) v2(48.42,36.12) v2(49.06,36.12) v2(50.04,80.67) v2(50.1,81.31) v2(53.25,114.1) v2(53.34,81.23) v2(53.56,113.6) v2(53.88,114.1) v2(54.07,71.69) v2(54.2,113.6) v2(54.23,66.45) v2(54.52,114.1) v2(57.69,125.92) v2(58.01,125.41) v2(58.33,125.92) v2(58.64,125.41) v2(58.96,125.92) v2(69.05,125.61) v2(69.05,125.03) v2(69.63,125.61) v2(69.63,125.03) v2(116.49,129.85) v2(116.49,129.22) v2(117.13,129.85) v2(117.13,129.22) v2(117.76,130.49) v2(117.76,129.85) v2(117.76,129.22) v2(118.4,130.49) v2(118.4,129.85) v2(145.89,50.92) v2(146.53,50.92) v2(146.49,41.88) v2(147.1,41.88) v2(147.16,50.92) v2(170.09,44.57) v2(170.21,44) v4(120.96,134.45) v4(148.12,46.64)
+3VALW_EC: length 208.3
  TOP w0.203: UE1.5 32.38,74.03 32.19,74.23 ; UE1.103 45.2,76.15 v2(45.02,75.97) ; UE1.65 50.01,63.23 50.26,62.98 50.26,61.51 51.04,60.73 51.42,60.73 CE10.1 ; UE1.22 32.38,67.23 32.29,67.32 ; v2(51.18,69.62) 50.77,70.03 UE1.82 ; UE1.19 32.23,68.43 32.21,68.42 ; CE13.1 40.32,79.58 40.32,78.64 40.4,78.56 UE1.115
  TOP w0.254: v2(112.1,29.64) 112.53,30.07 v2(112.53,36.03)
  TOP w0.305: RE11.2 v2(30.11,72.48) RE10.2 ; RE9.2 29.54,73.69 v2(30.03,74.18) 30.52,73.69 RE8.2
  TOP w0.457: v2(40.83,79.15) 40.83,79.45 CE13.1
  TOP w0.508: CE21.1 RE1.1 ; RE1.1 41.77,84.18 v2(41.73,84.22) ; RE1.1 42.42,85.1 CE8.2 42.42,85.13 CE5.1 RE2.2 v4(48.37,86.2) v2(50.2,86.2) ; v2(51.18,69.62) 51.25,69.62 51.63,69.24 CE11.1 ; v2(51.37,60.07) 51.84,60.07 51.93,60.16 CE10.1 ; 32.19,74.23 31.55,74.86 CE6.1 30.72,74.86 RE8.2 ; RE14.2 32.53,58.75 32.17,59.11 v2(31.02,59.11) ; RE3.1 45.82,80.49 CE12.1 v2(46.1,79.59)
  IN1 w0.254: v2(51.18,69.62) 51.18,68.99 49.82,67.62 49.82,61.62 v2(51.37,60.07) 51.48,59.96 51.48,56.1 50.22,54.85 50.22,45.45 58.3,37.37 61.67,37.37 62.04,36.99 87.25,36.99 87.44,36.8 103.14,36.8 104.05,37.71 110.84,37.71 v2(112.53,36.03)
  IN1 w0.508: v2(53.19,74.23) 51.09,76.34 51.09,82 50.2,82.89 v2(50.2,86.2)
  IN2 w0.508: v2(31.02,59.11) 33.05,61.15 37.75,61.15 39.12,59.78 v2(39.12,59.68) ; v2(53.19,74.23) 53.19,72.84 52.07,71.72 52.07,70.07 51.63,69.62 v2(51.18,69.62)
  BOTTOM w0.508: v2(50.2,86.2) 48.15,86.2 45.16,83.21 45.16,81.04 46.1,80.1 v2(46.1,79.59) 46.1,77.05 v2(45.02,75.97) ; v2(41.73,84.22) 41.8,84.15 41.8,80.52 40.83,79.55 v2(40.83,79.15) 40.83,78.11 38.17,75.45 38.17,60.62 v2(39.12,59.68)
  vias: v2(30.23,68.67)
+3VALW_PCH: length 145.2
  TOP w0.254: RC17.1 127.22,36.63 v2(126.55,35.96) ; v2(129.66,56.41) 129.66,56.42 129.54,56.54 129.54,56.97 130.44,57.87 131.77,57.87 132.21,57.43 132.21,56.54 133.23,55.53 v2(133.23,54.83) 133.23,54 130.11,50.88 124.01,50.88 122.84,52.05 122.84,53.6 v2(122.28,54.16) 122.68,54.56 RC39.2 RC47.2 123.64,54.83 v2(123.4,54.59) ; RC129.1 95.16,48.03 v2(95.08,47.95) ; v2(103.4,49.74) v4(102.82,49.74) 101.42,48.34 101.42,48.1 99.94,46.62 99.68,46.62 98.89,45.83 98.89,45.63 98.45,45.18 98.45,37.94 v2(98.56,37.83) ; v2(121.49,69.3) 121.52,69.3 121.93,68.89 L2.1
  TOP w0.508: CC78.1 125.12,66.95 v2(125.88,66.95)
  IN1 w0.254: v2(103.4,49.74) 103.48,49.74 104.66,50.92 108.02,50.92 109.75,52.66 121.72,52.66 122.28,53.22 v2(122.28,54.16) ; 117.51,66.61 117.13,66.23 116.56,66.23 115.93,65.6 115.93,63.63 114.14,61.84 113.29,61.84 111.77,60.33 110.26,60.33 108.55,58.61 107.79,58.61 v2(107.6,58.42) ; v2(126.55,35.96) 114.11,35.96 111.72,38.34 103.91,38.34 103.17,37.6 98.79,37.6 v2(98.56,37.83)
  IN2 w0.254: v2(95.08,47.95) 96.28,47.95 96.9,48.57 97.64,48.57 98.76,49.7 103.35,49.7 v2(103.4,49.74)
  IN2 w0.508: v2(127.35,68.68) 127.29,68.68 127.29,68.68 v2(125.61,68.68)
  BOTTOM w0.254: UC1.V19 126.77,70.32 v2(126.5,70.59) ; v2(125.61,68.68) 126.04,68.36 UC1.Y16 ; v2(123.4,54.59) 123.64,54.83 RC47.2 ; RC33.2 RC34.2 RC38.2 128.95,56.08 129.28,56.41 v2(129.66,56.41) 129.66,55.38 RC37.2 ; UC1.AG15 122.73,67.08 v2(122.77,67.04) ; UC1.T16 127.44,68.68 v2(127.35,68.68) ; UC1.AK17 121.21,69.02 v2(121.49,69.3) ; UC1.AJ21 122.63,72.37 123.75,72.37 123.76,72.36 v2(123.87,72.36) ; v2(125.88,66.95) 125.9,66.97 125.9,67.54 UC1.Y15 ; UC1.AD15 124.09,67.4 v2(124.09,67.35)
  BOTTOM w0.305: v2(133.23,54.83) 132.97,55.08 RC46.2
  BOTTOM w0.381: RC44.1 RC128.1 108.31,59.08 108.04,58.8 107.99,58.8 107.92,58.73 107.92,58.73 v2(107.6,58.42) 107.2,58.01 107.2,55.58 106.9,55.29 106.9,54.98 103.42,51.5 103.42,49.74 v2(103.4,49.74)
  vias: v2(145.9,63.96) v2(145.93,62.83)
+3VALWP: length 73
  TOP w0.254: PR304.1 v4(109.58,139.68) v2(110.4,138.87)
  IN1 w0.254: v2(158.94,142.47) 157.46,143.95 153.32,143.95 150.85,141.47 120.62,141.47 119.07,139.92 119.07,134.59 118.14,133.66 v2(117.13,133.66)
  IN2 w0.254: v2(115.22,132.9) 114.72,133.41 114.72,133.85 113.66,134.91 113.66,137.26 112.56,138.36 110.52,138.36 v2(110.4,138.23) ; v2(110.4,138.87) 110.52,138.74 112.81,138.74 114.04,137.51 114.04,135.1 115.22,133.92 v2(115.22,133.66)
  BOTTOM w0.254: v2(110.4,138.23) 110.65,138.23 110.9,138.48 PR307.1 111.25,138.5 PR306.2 ; PU301.14 110.08,138.94 110.14,138.87 v2(110.4,138.87) ; PR504.1 v2(158.94,142.47)
  vias: v2(114.21,133.66) v2(114.21,132.9) v2(115.86,133.66) v2(115.86,132.9) v2(116.49,133.66) v2(116.49,132.9) v2(117.13,132.9)
