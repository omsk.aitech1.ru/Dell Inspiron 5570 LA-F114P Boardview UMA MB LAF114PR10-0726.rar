# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
BST_+1VALW on BOTTOM (solid shape): 166.47,54.84 166.47,54.65 165.83,54.02 165.83,52.87 166.15,52.56 166.15,51.98 165.26,51.98 165.26,54.46 165.71,54.91 166.4,54.91
BST_+1VALW_R on BOTTOM (solid shape): 166.15,50.59 164.44,50.59 164.31,50.71 164.31,51.22 166.15,51.22
BST_VCCSA on BOTTOM (solid shape): 172.06,62.4 171.99,62.34 171.93,62.34 171.04,61.45 170.28,61.45 170.21,61.51 170.21,61.83 170.34,61.95 170.85,61.95 171.42,62.53 171.42,63.22 172.06,63.22
BST_VCORE1 on BOTTOM: 163.95,76.6 163.99,76.56 164.63,76.56 164.63,77.45 163.99,77.45 163.44,76.9 162.54,76.9 162.47,76.83 162.47,76.65 162.52,76.6
BST_VCORE1_R on BOTTOM (solid shape): 166.02,75.35 165.39,75.35 165.32,75.42 165.32,77.38 165.39,77.45 166.02,77.45
BST_VCORE2 on BOTTOM: 162.45,98.92 162.16,99.2 161.32,99.2 161.25,99.13 161.25,98.95 161.32,98.87 161.75,98.87 161.75,98.87 161.8,98.87 162.4,98.27 162.4,98.22 162.61,98.01 163.29,98.01 163.31,98.03 163.31,98.89 163.28,98.92
BST_VCORE2_R on BOTTOM (solid shape): 164.73,98.86 164.73,96.92 164.63,96.82 163.99,96.82 163.93,96.88 163.93,98.85 163.99,98.91 164.68,98.91
BST_VGT1 on BOTTOM (solid shape): 140.24,132.65 141.13,132.65 141.19,132.58 141.19,132.39 141.13,132.33 139.99,132.33 139.73,132.08 139.1,132.08 139.1,132.96 139.92,132.96
BST_VGT1_R on BOTTOM (solid shape): 138.34,132.08 137.7,132.08 137.7,134.17 138.34,134.17
HDMI_PLL_GND on TOP (solid shape): 16.77,101.69 16.77,96.16 16.34,95.73 14.62,95.73 14.36,95.99 14.36,99.94 16.18,101.76 16.7,101.76
IR_GND on BOTTOM (solid shape): 212.95,49.08 212.95,48.32 212.89,48.26 211.93,48.26 211.81,48.38 211.81,49.02 211.93,49.14 212.89,49.14
LG_1.2V on BOTTOM (solid shape): 94,133.64 94,133.53 93.92,133.46 93.16,133.46 92.31,134.31 92.31,134.56 92.4,134.65 92.98,134.65
LG_1.2V on IN2 (solid shape): 90.9,138.17 90.9,136.65 90.78,136.52 90.2,136.52 90.08,136.65 90.08,136.96 90.33,137.22 90.33,138.17 90.46,138.3 90.78,138.3
LG_1.2V on IN2 (solid shape): 93.25,134.34 93.25,133.87 93.15,133.76 92.85,133.76 92.25,134.36 91.98,134.36 91.6,134.74 91.6,134.93 91.98,135.31 92.27,135.31
LGATE_CHG on BOTTOM (solid shape): 191.3,45.52 191.3,45.27 191.17,45.14 189.14,45.14 189.01,45.27 189.01,45.59 189.07,45.65 191.17,45.65
LGATE_CHG on BOTTOM (solid shape): 197.58,50.99 198.73,50.99 198.78,50.94 198.78,50.81 198.7,50.73 197.77,50.73 197.52,50.83 197.27,50.73 196.44,50.73 196.31,50.86 196.31,51.11 196.44,51.24 197.33,51.24
LGATE_CHG on IN2 (solid shape): 192.5,45.72 192.5,45.46 192.19,45.14 190.28,45.14 190.15,45.27 190.15,45.52 190.28,45.65 191.55,45.65 191.8,45.91 192.31,45.91
LGATE_CHG on IN2 (solid shape): 197.46,51.11 197.46,50.83 197.32,50.77 197.22,50.67 197.01,50.67 196.38,50.03 196.06,50.03 195.74,50.35 195.74,50.54 196.44,51.24 197.33,51.24
LX_1.2V on TOP (solid shape): 87.28,139.12 87.28,137.6 87.16,137.47 85.63,137.47 85.51,137.6 85.51,139.12 85.63,139.25 87.16,139.25
LX_1.2V on BOTTOM (solid shape): 93.4,135.69 94.4,134.7 94.4,133.92 94.34,133.87 94.24,133.87 92.74,135.36 92.74,135.89 92.81,135.95 93.4,135.95
LX_1.2V on BOTTOM (solid shape): 89.89,140.14 92.93,140.14 92.93,139.06 90.33,139.06 88.74,137.47 84.49,137.47 83.92,138.04 83.92,141.35 84.17,141.6 88.43,141.6
LX_1.2V on IN2 (solid shape): 91.09,139.95 91.09,139.5 90.97,139.38 89.19,139.38 89.06,139.5 89.06,139.95 89.25,140.14 90.9,140.14
LX_1.2V on IN2 (solid shape): 93.76,135.89 93.76,135.06 94.08,134.74 94.08,134.49 93.95,134.36 93.7,134.36 93,135.06 93,135.89 93.13,136.01 93.63,136.01
LX_1.8VALW on TOP (solid shape): 163.04,47.98 163.74,47.29 163.74,46.46 163.61,46.33 161.64,46.33 161.39,46.59 161.39,48.68 163.04,48.68
LX_1.8VALW on BOTTOM (solid shape): 163.42,48.05 163.42,47.6 163.8,47.22 165.13,47.22 165.2,47.16 165.2,46.52 165.13,46.46 164.25,46.46 164.12,46.33 164.12,45.63 163.86,45.38 160.94,45.38 160.94,48.17 163.29,48.17
LX_3V on TOP (solid shape): 107.6,136.33 107.6,134.87 107.54,134.81 105.89,134.81 105.83,134.87 105.83,136.27 106.08,136.52 107.41,136.52
LX_3V on BOTTOM (solid shape): 107.62,138.22 107.62,131.14 107.29,130.81 103.86,130.81 103.09,131.57 103.09,135.25 103.22,135.38 105.38,135.38 106.02,136.01 106.02,137.41 106.9,138.3 107.54,138.3
LX_3V on BOTTOM (solid shape): 106.97,142.17 106.97,141.73 107.16,141.54 107.16,140.52 107.1,140.46 106.97,140.46 106.33,141.09 106.33,141.73 106.46,141.85 106.46,142.24 106.59,142.36 106.78,142.36
LX_3V on IN2 (solid shape): 106.99,142.21 107.02,142.09 107.1,141.99 107.1,139.06 107.67,138.49 107.67,136.84 107.54,136.71 106.71,136.71 106.59,136.84 106.59,138.04 106.08,138.55 106.08,142.17 106.27,142.36 106.84,142.36
LX_5V on TOP (solid shape): 157.77,134.3 157.77,133.15 157.64,133.03 155.48,133.03 155.23,133.28 155.23,134.17 155.48,134.42 157.64,134.42
LX_5V on BOTTOM (solid shape): 157.51,140.33 157.51,139 157.45,138.93 157.26,138.93 157.2,139 157.2,139.63 157.01,139.82 156.56,139.82 156.43,139.95 156.43,140.39 156.5,140.46 157.39,140.46
LX_5V on BOTTOM (solid shape): 157.96,136.65 157.96,135.25 158.53,134.68 159.99,134.68 160.18,134.49 160.18,132.2 160.05,132.08 155.61,132.08 155.04,132.65 155.04,134.98 155.18,135.12 155.61,135.12 157.26,136.77 157.83,136.77
LX_5V on IN2 (solid shape): 157.64,140.33 157.64,135.19 157.45,135 156.63,135 156.43,135.19 156.43,140.33 156.56,140.46 157.51,140.46
LX_+1VALW on TOP (solid shape): 165.01,56.3 165.01,55.1 164.75,54.84 162.78,54.84 162.78,56.49 164.82,56.49
LX_+1VALW on BOTTOM (solid shape): 167.04,56.94 167.04,55.41 166.91,55.29 165.77,55.29 164.88,54.4 164.88,51.6 164.31,51.6 164.31,52.62 163.8,53.13 161.96,53.13 161.96,56.87 162.28,57.19 166.79,57.19
LX_VCCSA on TOP (solid shape): 163.74,63.3 163.74,62.29 163.61,62.16 161.64,62.16 161.39,62.42 161.39,63.5 161.45,63.56 163.48,63.56
LX_VCCSA on BOTTOM (solid shape): 164.25,62.73 166.98,62.73 167.55,63.3 168.25,63.3 168.31,63.24 168.31,62.35 168.06,62.1 168.06,61.34 168.18,61.21 168.94,61.21 169.01,61.15 169.01,61.02 168.88,60.89 167.86,60.89 167.04,61.72 164.05,61.72 163.67,61.34 163.67,60.56 163.11,60 161.13,60 160.88,60.26 160.88,61.46 160.94,61.53 161.9,61.53 161.9,62.42 160.94,62.42 160.88,62.48 160.88,63.43 161.01,63.56 163.42,63.56
LX_VCORE1 on TOP (solid shape): 157.7,80.45 157.7,78.86 157.64,78.8 155.93,78.8 155.86,78.86 155.86,80.32 156.12,80.58 157.58,80.58
LX_VCORE1 on BOTTOM (solid shape): 159.74,85.7 159.74,79.1 158.53,79.1 158.28,78.85 158.28,75.1 157.64,75.1 157.18,75.56 154.85,75.56 154.28,76.13 154.28,80.5 156.05,82.27 156.05,83.23 156.37,83.54 158.28,83.54 158.28,84.43 157.32,84.43 157.32,85.7 157.39,85.77 159.67,85.77
LX_VCORE2 on TOP (solid shape): 155.23,102.99 155.23,101.66 154.97,101.4 153.58,101.4 153.45,101.53 153.45,103.12 153.51,103.18 155.04,103.18
LX_VCORE2 on BOTTOM (solid shape): 158.59,101.97 158.59,101.4 158.53,101.34 157.2,101.34 157.07,101.21 157.07,97.34 153.51,97.34 152.56,98.29 152.56,100.58 151.67,100.58 151.67,99.63 150.34,99.63 150.34,102.53 150.66,102.85 157.72,102.85
LX_VGT1 on TOP (solid shape): 146.85,128.96 146.85,127.57 146.59,127.31 145.32,127.31 145.07,127.57 145.07,128.96 145.2,129.09 146.72,129.09
LX_VGT1 on BOTTOM (solid shape): 147.23,133.72 147.23,123.75 146.87,123.39 144.36,123.39 144.18,123.58 144.18,124.58 144.37,124.77 145.45,124.77 145.45,125.66 144.12,125.66 143.86,125.92 143.86,130.17 143.93,130.23 145.2,130.23 145.32,130.36 145.32,134.17 146.78,134.17
PHASE_CHG on TOP (solid shape): 187.42,50.22 187.42,48.95 187.16,48.68 185.53,48.68 184.94,49.28 184.94,50.39 185.1,50.55 187.09,50.55
PHASE_CHG on BOTTOM (solid shape): 187.17,50.67 187.17,48.83 188.38,47.62 188.38,44.83 186.03,42.48 180.25,42.48 180.06,42.67 180.06,46.54 180.5,46.99 183.68,46.99 185.01,48.32 185.01,50.41 185.39,50.8 187.04,50.8
PHASE_CHG on BOTTOM (solid shape): 197.77,51.37 198.73,51.37 198.78,51.32 198.78,51.19 198.74,51.15 197.61,51.15 197.39,51.37 196.19,51.37 195.8,50.99 195.3,50.99 195.23,51.05 195.23,51.68 195.42,51.87 197.27,51.87
PHASE_CHG on IN2 (solid shape): 186.91,50.67 186.91,50.35 186.6,50.03 185.14,50.03 184.95,50.22 184.95,50.54 185.2,50.8 186.79,50.8
PHASE_CHG on IN2 (solid shape): 197.46,51.75 197.46,51.49 197.33,51.37 196.25,51.37 196,51.11 195.68,51.11 195.55,51.24 195.55,51.75 195.68,51.87 197.33,51.87
PHASE_VCORE1 on BOTTOM (solid shape): 164.63,75.35 163.42,75.35 163.17,75.61 162.53,75.61 162.47,75.67 162.47,75.86 162.53,75.92 163.23,75.92 163.55,76.24 164.63,76.24
PHASE_VCORE2 on BOTTOM (solid shape): 162.63,97.72 163.23,97.72 163.23,96.82 162.58,96.82 162.29,97.11 162.29,97.5 161.9,97.9 161.32,97.9 161.26,97.96 161.26,98.15 161.32,98.21 162.14,98.21
PHASE_VGT1 on BOTTOM (solid shape): 140.24,133.66 141.13,133.66 141.19,133.6 141.19,133.41 141.07,133.28 140.31,133.28 140.24,133.22 139.16,133.22 139.1,133.28 139.1,134.17 139.73,134.17
REGOUT on TOP: 22.11,87.27 21.92,87.46 21.76,87.83 21.35,87.76 20.51,88.61 20.07,88.61 18.96,89.72 18.96,90.74 20.86,90.74 20.99,90.61 20.99,90.17 21.18,89.97 21.75,89.97 23.19,88.54 23.19,87.32 23.14,87.27
RING2 on TOP: 31.12,17.38 30.86,17.12 30.67,17.12 30.42,17.38 30.42,18.22 30.07,18.57 30.07,19.68 31.53,19.68 31.59,19.62 31.59,19.17 31.12,18.7
RING2_R on TOP (solid shape): 18.32,8.5 18.32,7.42 18,7.11 14.32,7.11 14.19,7.23 14.19,7.55 14.83,8.19 16.61,8.19 17.18,8.76 18.07,8.76
RING2_R on IN1 (solid shape): 15.34,8.06 15.34,7.23 15.21,7.11 14.39,7.11 14.26,7.23 14.26,7.49 14.96,8.19 15.21,8.19
RING2_R on IN2 (solid shape): 19.21,9.39 19.21,8.89 18.26,7.93 17.18,7.93 16.99,8.12 16.99,8.57 17.24,8.82 17.62,8.82 18.39,9.58 19.02,9.58
RING2_R on TOP: 31.75,20.12 31.6,19.97 31.06,19.97 30.96,20.07 30.96,20.56 31.05,20.66 31.05,23.41 31.24,23.6 31.56,23.6 31.75,23.41
RING2_R on IN2: 30.91,23.45 30.91,21.49 31.09,21.31 31.87,21.31 31.96,21.4 31.96,23.49 31.78,23.67 31.13,23.67
SLEEVE on TOP: 30.29,18.09 30.29,17.25 30.23,17.19 29.91,17.19 28.42,18.68 28.42,19.62 28.48,19.68 29.94,19.68 29.94,18.44
SLEEVE_R on TOP (solid shape): 15.91,12 15.91,10.73 16.1,10.54 17.56,10.54 17.88,10.85 17.88,11.23 18.07,11.43 18.64,11.43 18.96,11.11 18.96,9.9 18.07,9.01 16.42,9.01 14.77,10.66 14.77,12 14.96,12.19 15.72,12.19
SLEEVE_R on IN1 (solid shape): 15.91,12.95 15.91,11.74 15.78,11.62 14.89,11.62 14.77,11.74 14.77,13.08 14.96,13.27 15.59,13.27
SLEEVE_R on IN2 (solid shape): 18.89,12.12 18.89,10.54 18.58,10.22 18,10.22 17.88,10.35 17.88,12.12 18.07,12.31 18.7,12.31
SLEEVE_R on TOP: 28.13,23.35 28.32,23.54 28.83,23.54 29.02,23.35 29.02,20.07 28.97,20.02 28.34,20.02 28.13,20.22
SLEEVE_R on IN2: 27.74,23.36 27.74,21.99 27.92,21.81 28.96,21.81 29.08,21.93 29.08,23.46 28.89,23.65 28.03,23.65
SNB_VCCSA on TOP (solid shape): 163.04,58.54 162.98,58.48 162.09,58.48 162.02,58.54 162.02,59.05 161.32,59.75 161.32,60.76 161.39,60.83 163.04,60.83
SNUB_+1VALW on TOP (solid shape): 167.55,56 167.55,54.99 167.36,54.79 165.45,54.79 165.45,54.8 165.45,56.51 165.52,56.57 166.98,56.57
UG_1.2V on BOTTOM (solid shape): 90.9,141.6 90.9,141.28 90.78,141.16 89.38,141.16 89.19,141.35 89.19,141.66 89.32,141.79 90.71,141.79
UG_1.2V on BOTTOM (solid shape): 94.81,135.86 94.81,133.92 94.76,133.87 94.64,133.87 94.59,133.92 94.59,134.73 94.22,135.1 94.22,135.87 94.32,135.97 94.7,135.97
UG_1.2V on IN2 (solid shape): 91.03,141.6 91.03,141.03 90.97,140.97 89.32,140.97 89.19,141.09 89.19,141.6 89.32,141.73 90.9,141.73
UG_1.2V on IN2 (solid shape): 94.84,136.58 94.84,135 94.71,134.87 94.4,134.87 94.27,135 94.27,136.08 94.08,136.27 94.08,136.58 94.14,136.65 94.78,136.65
UGATE_CHG on BOTTOM (solid shape): 197.14,52.95 197.14,52.75 197.58,52.3 197.58,52.13 197.93,51.79 198.71,51.79 198.78,51.72 198.78,51.61 198.73,51.56 197.77,51.56 197.14,52.19 196.31,52.19 196.31,53.08 196.38,53.14 196.95,53.14
USB20_VCC on BOTTOM (solid shape): 201.52,39.87 201.52,36.3 201.33,36.11 198.09,36.11 197.9,36.3 197.9,37.7 198.54,38.35 198.54,38.35 198.66,38.47 198.66,39.24 199.49,40.06 201.33,40.06
USB30_VCCA on TOP (solid shape): 19.72,46.41 19.72,44 19.34,43.62 18.07,43.62 17.69,44 17.69,46.03 18.32,46.67 19.47,46.67
USB30_VCCA on TOP (solid shape): 23.66,57.46 23.66,55.94 22.01,54.29 21.12,54.29 20.48,54.92 20.48,55.56 21.62,56.7 21.62,57.34 22.13,57.84 23.28,57.84
USB30_VCCA on BOTTOM (solid shape): 24.29,58.73 24.29,56.95 23.89,56.55 17.84,56.55 17.31,56.03 15.72,56.03 15.41,56.35 15.41,58.31 15.44,58.34 16.1,59 24.02,59
USB30_VCCA on BOTTOM (solid shape): 19.21,44.76 19.21,43.49 19.72,42.98 20.35,42.98 20.61,42.73 20.61,42.48 20.35,42.22 19.97,42.22 19.34,41.59 19.34,38.79 18.07,37.52 18.07,37.4 17.7,37.03 17.7,32.84 16.93,32.06 15.78,32.06 15.27,32.57 15.27,33.59 15.28,33.6 15.28,34.07 15.66,34.45 15.66,37.65 16.93,38.92 16.93,44.38 17.43,44.89 19.08,44.89
N17237617 on TOP (solid shape): 191.93,52.51 191.93,48.62 191.76,48.45 188.73,48.45 188.61,48.57 188.61,50.65 190.66,52.7 191.74,52.7
N17237617 on BOTTOM (solid shape): 191.99,56.89 191.99,48.45 191.93,48.38 188.18,48.38 187.74,48.83 187.74,51.94 187.17,52.51 187.17,54.67 187.74,54.67 187.74,56.7 187.17,56.7 187.17,57.53 187.42,57.78 191.11,57.78
N17415515 on BOTTOM (solid shape): 79.36,147.12 79.66,146.96 79.96,147.12 83.09,147.12 83.85,146.36 83.85,143.19 83.6,142.94 76.36,142.94 76.04,143.25 76.04,146.81 76.36,147.12
N21222441 on BOTTOM (solid shape): 198.78,49.73 198.78,49.6 198.73,49.55 197.93,49.55 197.01,48.64 197.01,45.33 196.95,45.27 195.93,45.27 195.87,45.33 195.87,48.57 196.06,48.76 196.59,48.76 197.29,49.46 197.42,49.54 197.5,49.67 197.61,49.78 198.73,49.78
N21242279 on TOP (solid shape): 183.93,64.07 183.93,63.18 182.91,62.16 182.91,59.62 182.53,59.24 179.74,59.24 179.49,59.49 179.49,62.29 179.74,62.54 181.14,62.54 181.64,63.05 181.64,64.07 181.77,64.19 183.8,64.19
N21269026 on TOP (solid shape): 158.53,103.12 158.53,102.48 158.47,102.42 157.45,102.42 157.26,102.23 157.26,101.47 157.2,101.4 156.18,101.4 156.12,101.47 156.12,103.06 156.24,103.18 158.47,103.18
N21273981 on TOP (solid shape): 146.85,132.65 146.85,130.74 146.72,130.61 145.2,130.61 145.17,130.64 145.17,132.62 145.32,132.77 146.72,132.77
N21380741 on BOTTOM (solid shape): 160.69,135.31 161.77,135.31 161.83,135.25 161.83,134.42 161.77,134.36 160.75,134.36 159.29,135.82 158.66,135.82 158.53,135.95 158.53,136.65 158.66,136.77 159.23,136.77
N21389189 on TOP (solid shape): 171.91,47.5 171.91,46.49 171.69,46.27 170.28,46.27 170.13,46.12 169.07,46.12 168.82,46.37 168.82,47.6 168.94,47.73 171.68,47.73
N21389189 on BOTTOM (solid shape): 171.91,47.5 171.91,46.12 171.74,45.95 167.48,45.95 167.36,46.08 167.36,47.16 167.42,47.22 168.5,47.22 169.01,47.73 171.68,47.73
N28484451 on TOP: 121.11,144.14 119.99,144.14 119.67,143.82 119.67,141.79 119.86,141.6 121.1,141.6 121.24,141.73 121.24,144.02
N28714564 on BOTTOM (solid shape): 195.61,54.35 195.61,53.53 195.55,53.46 194.85,53.46 194.73,53.34 194.73,52.07 194.92,51.87 194.92,51.05 194.85,50.99 194.34,50.99 194.28,51.05 194.28,54.16 194.53,54.41 195.55,54.41
N28714606 on BOTTOM (solid shape): 187.17,52 187.17,51.18 186.98,50.99 186.22,50.99 186.03,51.18 186.03,52 186.15,52.13 187.04,52.13
N28714606 on BOTTOM (solid shape): 196.19,53.08 196.19,52.19 196.06,52.07 195.04,52.07 194.92,52.19 194.92,53.14 194.98,53.21 196.06,53.21
N28714606 on IN2 (solid shape): 187.99,52.07 187.99,51.56 187.87,51.43 186.28,51.43 186.03,51.68 186.03,52.07 186.15,52.19 187.87,52.19
N28714606 on IN2 (solid shape): 196.19,53.08 196.19,52.19 196.06,52.07 194.92,52.07 194.73,52.26 194.73,52.76 195.17,53.21 196.06,53.21
N28714612 on BOTTOM (solid shape): 197.9,53.53 197.9,53.12 198.02,52.99 198.02,52.45 198.28,52.19 198.73,52.19 198.79,52.13 198.79,52 198.73,51.94 197.96,51.94 197.75,52.15 197.75,52.37 197.33,52.79 197.33,53.21 197.14,53.4 196.31,53.4 196.25,53.46 196.25,54.35 196.31,54.41 197.01,54.41
N28714617 on TOP (solid shape): 188.38,62.42 188.38,56.19 187.55,55.37 185.71,55.37 185.71,55.94 187.23,55.94 187.23,56.64 185.71,56.64 185.71,57.34 185.07,57.97 183.68,57.97 183.42,58.22 183.42,62.16 183.93,62.67 188.12,62.67
N28714693 on BOTTOM (solid shape): 178.79,53.14 178.79,52.13 179.04,51.87 180.37,51.87 180.82,52.32 180.82,53.14 181.07,53.4 183.93,53.4 184.12,53.21 184.12,51.56 183.87,51.3 183.87,48.7 179.93,48.7 178.66,49.97 177.96,49.97 177.33,50.6 177.33,52.32 176.69,52.32 176.69,52.29 176.69,50.79 176.56,50.67 176.06,50.67 175.87,50.86 175.87,53.02 176.25,53.4 178.53,53.4
N28714782 on TOP (solid shape): 188.44,47.18 188.44,46.29 188.31,46.16 185.71,46.16 185.64,46.22 185.64,47.24 185.71,47.3 188.31,47.3
N28714793 on BOTTOM (solid shape): 180.25,53.27 180.25,52.26 180.12,52.13 179.1,52.13 178.98,52.26 178.98,53.14 179.23,53.4 180.12,53.4
N45789065 on TOP (solid shape): 158.59,77.08 158.59,76.2 158.53,76.13 155.99,76.13 155.93,76.2 155.93,77.15 155.99,77.21 158.47,77.21
N47714748 on TOP (solid shape): 90.84,139.12 90.84,138.62 90.71,138.49 90.2,138.49 89.95,138.23 89.95,137.6 89.82,137.47 88.93,137.47 88.81,137.6 88.81,139.12 88.93,139.25 90.71,139.25
N47719295 on TOP (solid shape): 91.94,133.07 91.94,132.1 91.89,132.06 90.93,132.06 90.68,132.31 90.68,133 90.77,133.09 91.92,133.09
N47719295 on BOTTOM (solid shape): 92.53,132.48 93.95,132.48 93.99,132.44 93.99,132.3 93.95,132.27 93.02,132.27 92.82,132.06 90.93,132.06 90.68,132.31 90.68,133 90.77,133.09 91.92,133.09
N47887852 on TOP (solid shape): 163.93,45.83 163.93,45.19 163.74,45 161.39,45 161.39,46.02 163.74,46.02

Small or netless copper shapes (teardrops, artwork): 219 on TOP, 134 on BOTTOM

## Text on the board
Ref Des/Silkscreen Bottom: H12 | M2L4
User.Comments: LAF114P | Monika | 2018-06-15 | 2017-06-15 | CAL60
User.38: trace Width | 7.6mil | 5.9mil | 42 ohm
User.39: FIGURE | SIZE | 8.0 | 22.0 | 28.0 | 35.0 | 118.0 | 126.0 | 130.0 | 146.0 | 157.0 | 197.0 | 43.0 | 63.0 | 220.0 | 55.0x24.0 | 63.0x24.0 | 63.0x35.0 | 71.0x31.0 | 102.0x31.0 | 157.0x118.0 | 157.0x146.0 | DRILL CHART: TOP to BOTTOM | ALL UNITS ARE IN MILS | TOLERANCE | +3.0/-3.0 | +2.0/-2.0 | PLATED | NON-PLATED | QTY | 4368 | 19 | 18 | 8 | 6 | 1 | 4 | 7
