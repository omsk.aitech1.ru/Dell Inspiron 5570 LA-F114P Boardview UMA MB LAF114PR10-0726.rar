# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VLP: length 220.9
  TOP w0.254: RE29.2 39.75,85.29 v2(39.71,85.33) ; v2(47.21,54.8) 47.25,54.83 v4(50.04,54.83) 51.37,56.16 51.37,58.43 51.53,58.59 R42.1
  TOP w0.508: v2(90.38,33.97) 90.93,34.51 90.93,35.61 91.25,35.92 D1.2
  IN1 w0.508: v2(90.38,33.97) 62.9,33.97 61.02,35.85 56.85,35.85 47.98,44.72 47.98,52.26 47.21,53.02 v2(47.21,54.8) 47.21,56 46.08,57.13 46.08,60.38 43.31,63.16 43.31,64.99 42.67,65.62 42.67,74.29 42.67,74.3 42.67,77.68 43.02,78.03 43.02,82.03 v2(39.71,85.33) 39.4,85.64 39.4,94.54 v2(41.5,96.64) ; v2(110.69,137.41) 108.56,137.41 108.33,137.64 103.95,137.64 98.81,142.77 83.15,142.77 79.76,139.38 77.38,139.38 70.81,132.81 62.38,132.81 v2(57.93,128.35)
  BOTTOM w0.508: v2(41.5,96.64) 41.5,120.21 50.68,129.39 57.13,129.39 57.93,128.6 v2(57.93,128.35)
+3VS: length 521.2
  TOP w0.254: Q10.2 121.07,28.38 121.64,27.8 121.79,27.8 ; US1.3 192.9,41.77 CS29.1 192.87,41.27 US1.2 ; US1.10 v2(188.84,38.2) 188.2,38.84 188.2,41.08 188.39,41.27 US1.9 ; RC207.2 RC212.2 127.97,59.24 128.35,58.86 129.27,58.86 129.5,58.63 RC205.2 129.5,57.62 v2(129.4,57.51)
  TOP w0.305: QC1.2 131.88,55.08 RC28.1 132.13,55.22 132.59,54.76 132.59,53.94 131.89,53.24 129.25,53.24 129.22,53.27 v2(129.21,53.27) 129.21,53.32 127.83,54.7 RC27.1 128.72,54.81 128.98,55.08 QC1.5
  TOP w0.381: v2(69.04,67.72) 69.04,67.41 69.34,67.11 70.41,67.11 RD3.1 ; RD2.1 71.17,44.52 71.5,44.19 v2(71.5,43.93)
  TOP w0.432: v2(118.45,25.51) 120.6,25.51 121.07,25.98 Q10.5
  TOP w0.508: R36.1 101.06,31.55 v2(101.06,33.02) 101.86,33.82 101.86,40 100.66,41.21 100.66,42.98 101.14,43.47 102.57,43.47 103.22,44.12 103.22,46.52 103.92,47.22 103.92,48.06 104.73,48.88 RC114.1 v2(104.73,49.63) 104.73,50.16 104.63,50.26 RC188.1 RC73.1 RC72.1 ; 122.02,27.68 121.92,27.68 121.79,27.8 ; 122.02,27.68 122.11,27.59 R34.1 ; 122.02,27.68 v2(122.02,27.69) ; QA1.2 39.45,23.15 37.02,20.71 RA2.1 35.09,23.81 v2(35.21,23.93) ; v2(211.36,54.54) 211.54,54.72 R5.1 ; v2(25.75,106.1) 25.35,105.7 23.42,105.7 23.02,106.1 21.61,106.1 v2(21.4,105.89) ; RC105.1 146.37,106.94 v2(146.99,107.55) ; RE13.2 37.4,59.37 v2(37.12,59.65) ; v2(56.8,45.41) 56.14,45.41 55.29,44.56 52.05,44.56 51.2,45.41 48.23,45.41 47.15,46.49 v2(47.15,52.16) 46.52,52.79 46.52,57.14 46.43,57.23 46.43,58.95 46.82,59.35 CE22.1 47.13,59.33 UE2.5 ; R7.1 208.2,32.06 v2(207.98,31.84) 207.36,31.22 206.77,31.22 202.63,35.36 v2(202.28,35.36) ; v2(30.44,122.77) 30.44,122.61 29.88,122.06 24.34,122.06 v2(24.09,121.8) ; v2(118.45,25.51) 117.96,25.51 117.45,26.02 R33.1 116.21,26.58 115.58,27.21 115.58,29.42 115.6,29.45 v2(115.6,30.28) ; RX6.1 v2(115.99,37.71) ; RC194.2 195.92,60.28 v2(195.94,60.26) ; RL3.1 v2(27.21,91.55) ; v2(120.94,44.83) 121.33,44.83 121.57,44.59 121.57,43.01 122.49,42.1 122.49,41.84 RC181.1 122.75,41.58 RC57.1 123.58,41.54 v2(123.58,40.62) ; RC69.2 135.28,57.26 v2(135.46,57.08) 135.75,57.37 141.99,57.37 142.55,57.93 v2(142.55,59.23) ; v2(195.42,40.86) 195.42,41.14 194.76,41.8 CS30.1 194.2,41.54 CS29.1 ; v2(128.47,41.78) 128.86,42.17 128.86,45.22 128.66,45.42 127.79,45.42 v2(127.62,45.26) ; v2(191.04,37.71) RS3.1 ; RD1.1 76.04,46.78 CD9.1 77.71,46.28 CD10.1 78.3,46.26 79.3,45.26 v2(79.3,43.9) 79.26,43.94 77.43,43.94 76.21,42.72 72.43,42.72 71.5,43.64 v2(71.5,43.93) ; RC195.1 212.09,33.59 v2(211.6,34.07) ; RD15.1 v2(56.96,67.94)
  TOP w2.032: 101.51,121.09 79.09,121.09 77.06,123.12 74.33,123.12
  IN1 w0.508: v2(107.1,49.27) 109.19,47.18 109.19,46.6 110.26,45.54 v2(110.26,44.93) ; v2(29.41,82.04) 29.66,82.29 29.66,83.05 29.13,83.59 29.13,87.89 27.21,89.81 v2(27.21,91.55) 27.21,104.64 v2(25.75,106.1) ; v2(71.5,43.93) 71.5,43.65 71.09,43.24 64.68,43.24 63.76,44.16 v2(63.76,44.63) ; v2(21.4,105.89) 21.4,108.77 22.59,109.96 22.59,120.3 v2(24.09,121.8) ; v2(38.42,55.4) 37.12,56.7 v2(37.12,59.65)
  IN2 w0.254: v2(129.4,57.51) 129.09,57.21 129.09,56.29 130.34,55.05 130.34,54.16 129.45,53.27 v2(129.21,53.27)
  IN2 w0.508: v2(146.99,107.55) 146.93,107.55 144.95,109.52 144.95,110.88 145.58,111.5 145.58,115.15 146.15,115.72 147.4,115.72 147.75,116.06 147.75,116.99 148.8,118.04 v2(157.53,118.04) ; v2(202.24,52.61) 202.14,52.52 200.1,52.52 199.27,53.35 199.27,54.63 195.94,57.96 v2(195.94,60.26) ; v2(47.15,52.16) 41.65,52.16 v2(41.34,52.48) v2(38.42,55.4) ; v2(129.21,53.27) 129.01,53.08 129.01,52.02 v2(129,52.01) 129.01,52 129.01,50.74 127.62,49.35 v2(127.62,45.26) ; v2(223.15,32.52) 223.15,31.4 222.04,30.3 v2(216.75,30.3) 213.63,30.3 212.09,31.84 v2(207.98,31.84)
  BOTTOM w0.254: UX1.8 109.71,42.67 CX3.1
  BOTTOM w0.305: v2(79.3,43.9) 79.3,43.98 80.07,44.75 81.57,44.75 82.14,45.32 82.14,46.48 81.88,46.74 JDIMM1.255 ; JDIMM2.255 65.6,46.74 64.88,46.03 v2(63.44,46.03)
  BOTTOM w0.356: v2(120.94,44.83) 120.94,45.46 120.37,46.03 UC4.5
  BOTTOM w0.381: U2.1 102.51,123.83 102.24,124.11 C21.1 ; QI2.5 25.54,105.89 v2(25.75,106.1) ; RI15.1 20.72,107.54 QI3.2 20.72,106.16 20.99,105.89 v2(21.4,105.89) 21.6,105.68 22.3,105.68 22.5,105.89 QI2.2 ; RC36.1 RC42.1 RC55.1 127.13,53.43 127.29,53.27 v2(129.21,53.27)
  BOTTOM w0.432: R49.1 104.04,127.85 Q11.5 ; Q11.2 107,127.85 107.46,127.39 R48.1
  BOTTOM w0.457: v2(110.26,44.93) 109.84,44.52 109.79,44.52 109.74,44.46 CX4.1 CX3.1
  BOTTOM w0.508: v2(69.04,67.72) 69.04,67.12 68.68,66.77 68.68,46.75 69.03,46.41 69.03,45.52 69.79,44.76 71.12,44.76 71.5,44.38 v2(71.5,43.93) ; PRZ16.1 157.26,117.77 v2(157.53,118.04) ; v2(29.41,82.04) 29.41,81.11 30.76,79.75 33.51,79.75 36.9,76.36 36.9,59.87 v2(37.12,59.65) ; v2(129,52.01) 132.6,52.01 135.43,54.83 RC35.1 RC209.1 136.2,56.56 135.68,57.08 v2(135.46,57.08) ; v2(207.98,31.84) 207.99,31.84 210.22,34.07 v2(211.6,34.07) ; v2(202.28,35.36) 202.28,35.88 202.2,35.97 JIOB1.12 ; RC213.2 v2(223.15,32.52) ; v2(104.73,49.63) 106.62,49.63 106.98,49.27 v2(107.1,49.27) 107.41,49.59 107.41,51.93 107.7,52.21 107.7,54.95 108,55.25 108,57.6 108.54,58.14 RC115.1 ; R49.1 103.7,128.2 v2(103.7,128.77) ; R29.1 v2(101.51,128.81) ; R50.2 177.63,66.9 177.63,65.69 180.91,62.42 181.9,62.42 186.15,58.16 193.85,58.16 v2(195.94,60.26) ; R79.1 30.56,121.5 30.56,122.64 v2(30.44,122.77) ; R80.1 v2(24.09,121.8) ; RC3.2 141.94,62.2 RC86.1 141.94,60.91 RC1.2 RC2.2 v2(142.55,59.23) ; R48.1 v2(108.24,127.39) ; v2(122.02,27.69) 122.02,26.47 121.05,25.51 v2(118.45,25.51) ; R28.1 v2(110.64,127.64) ; v2(79.41,35.28) 79.41,36.44 78.4,37.45 Q6.2 76.81,37.45 R24.1 ; v2(101.61,123.43) 101.61,123.43 C21.1 ; v2(56.96,67.94) 56.65,67.94 56.35,67.64 56.35,45.86 v2(56.8,45.41)
  vias: v2(27.28,47.05) v2(27.28,46.41) v2(27.28,45.78) v2(27.28,45.14) v2(27.28,44.51) v2(123.35,133.59) v2(123.35,132.95) v2(123.61,134.22) v2(123.99,133.59) v2(123.99,132.95) v2(124.24,134.22) v2(124.62,133.59) v2(124.62,132.95) v2(124.88,134.22) v2(125.38,133.7) v2(219.55,59.67) v2(219.55,59.03) v2(220.19,59.67) v2(220.19,59.03) v2(220.38,47.67) v2(220.38,47.03) v4(110.04,125.23)
+3VS_CAM: length 6.2
  TOP w0.508: R16.2 217.52,47.35 217.46,47.29 C15.1 216.11,47.29 216.11,47.29 C14.1 v1(214.49,47.29) 214.18,47.29 213.79,46.9 v2(213.44,46.9)
  BOTTOM w0.305: JEDP1.29 213,46.45 v2(213.44,46.9)
+3VS_SSD: length 2.1
  TOP w0.508: CS27.1 35.86,27.62 v2(36.17,27.94) ; CS25.1 v2(38.01,27.9)
  vias: v2(21.37,27.72) v2(22.01,27.72) v2(23.3,29.64) v2(23.3,29) v2(23.3,28.37) v2(37.37,27.87) v4(22.41,28.56) v4(22.82,25.66) v4(35.49,28.74)
+5V_AVDD: length 11
  TOP w0.102: v1(19.66,23.2) 20.06,22.79 RA4.2
  TOP w0.508: RA4.2 21.05,20.47 20.56,19.97 20.56,19.34 20.86,19.03 21.32,19.03 21.69,18.66 25.05,18.66 25.43,18.28 CA11.1
+5V_HDD: length 6.7
  TOP w0.102: v4(185.63,38.03) 185.96,37.7 RS4.1 ; v4(184.12,36.39) v2(184.12,34.86) v4(184.12,34.02)
  TOP w0.508: v2(184.12,34.86) 185.59,36.33 RS4.1
+5V_HDMI:
  vias: v4(14.89,102.19)
+5V_KB_BL: length 10.3
  TOP w0.508: F3.1 v1(93,27.87) 94.14,27.87 94.51,28.24 C34.1 EC3002.1 94.51,33.03 v2(94.64,33.16)
  BOTTOM w0.406: v2(94.64,33.16) 95.05,33.58 JKBBL1.1
+5V_PVDD:
  vias: v2(28.6,8.14) v2(29.03,8.56) v2(31.66,8.12) v2(32.23,7.93) v4(32.67,8.59)
+5VALW: length 250.5
  TOP w0.203: UZ3.4 v2(126.97,137.2)
  TOP w0.254: UZ1.4 149.47,67.51 149.67,67.72 149.67,68.37 CZ22.1
  TOP w0.508: CZ22.1 150.14,68.48 v2(150.23,68.57) ; v2(151.67,59.14) 150.85,59.14 150.07,59.93 CZ5.1 149.65,60.12 149.28,60.49 UZ2.3 ; v2(153.07,106.36) 151.15,106.36 150.48,107.03 PRZ39.1 ; v2(138.59,129.47) v4(139.67,128.39) PCG11.1 142.52,129.06 v2(142.52,129.07) ; PR4.1 88.96,145.14 PD3.3 89.96,146.37 PD2.3 89.93,147.42 v2(90.2,147.7) ; v2(16.48,118.6) 16.48,122.53 v2(16.62,122.66) ; CZ23.1 127.76,137.89 v2(127.35,138.29) ; v2(164.75,80.81) 165.72,81.78 v4(165.72,87.69) v2(165.72,97.34)
  IN1 w0.508: v2(168.06,50.33) 168.06,50.56 167.56,51.05 163.68,51.05 163.04,50.41 154.03,50.41 152.44,52.01 152.44,57.49 151.67,58.26 v2(151.67,59.14) 151.73,59.14 153.51,60.93 153.51,64.22 150.23,67.51 v2(150.23,68.57) ; v2(24.23,41.4) 24.23,36.89 26.68,34.44 43.48,34.44 44.33,33.59 48.68,33.59 v2(49.86,32.41) ; v2(138.59,129.47) 131.62,136.44 v2(130.72,136.44) ; v2(16.62,122.66) 19.68,125.73 29.38,125.73 31.22,127.57 50.26,127.57 v2(53.06,130.36)
  IN2 w0.508: v2(168.06,50.33) 168.06,50.11 168.45,49.71 171.29,49.71 174.53,52.95 v2(174.53,58.73) ; v2(90.89,131.38) 91.05,131.54 97.42,131.54 98.27,132.39 98.27,139.76 94.81,143.21 91.86,143.21 90.2,144.87 v2(90.2,147.7)
  BOTTOM w0.254: PRI02.1 164.07,79.87 163.69,79.49 163.69,78.82 163.12,78.25 PUI01.2 ; PRI22.1 162.78,101.39 161.93,100.54 PUI02.2 ; PUI01.15 v2(161.12,80.17)
  BOTTOM w0.305: PUG01.15 v2(142.52,129.07) ; PUI02.15 v2(159.93,102.55)
  BOTTOM w0.381: v2(168.06,50.33) 167.99,50.4 167.99,50.64 PRH11.1
  BOTTOM w0.508: v2(165.72,97.34) 165.72,99.97 164.31,101.39 PCI31.1 PRI22.1 ; v2(49.86,32.41) 49.95,32.32 PR2504.1 ; PRI02.1 PCI11.1 165.13,80.43 v2(164.75,80.81) ; Q19.3 v2(16.62,122.66) ; Q18.3 v2(16.48,118.6) ; v2(174.53,58.73) 174.36,58.91 PCA08.1 ; PRG02.1 138.61,129.49 v2(138.59,129.47) ; PRZ57.1 144.18,110.67 144.18,107.84 144.67,107.35 144.67,105.74 146.16,104.25 151.85,104.25 152.35,104.75 v2(154.72,104.75)
  BOTTOM w3.048: 50.28,123.3 48.07,121.09 48.04,121.09 46.14,119.18 46.14,116.26
  vias: v2(22.96,42.03) v2(22.96,41.4) v2(23.59,42.03) v2(23.59,41.4) v2(24.23,42.03) v2(45.75,114.23) v2(45.75,113.6) v2(46.39,114.23) v2(46.39,113.6) v2(47.02,114.23) v2(47.02,113.6) v2(50.47,125.94) v2(50.47,125.31) v2(51.1,125.94) v2(51.1,125.31) v2(51.74,125.94) v2(51.74,125.31) v2(128.81,137.71) v2(128.81,137.07) v2(128.81,136.44) v2(129.45,137.71) v2(129.45,137.07) v2(129.45,136.44) v2(130.08,138.34) v2(130.08,137.71) v2(130.08,137.07) v2(130.08,136.44) v2(130.72,138.34) v2(130.72,137.71) v2(130.72,137.07) v2(156.12,122.49) v2(156.12,121.85) v2(156.12,121.22) v2(156.75,122.49) v2(156.75,121.85) v2(156.75,121.22) v2(157.39,122.49) v2(157.39,121.85) v2(157.39,121.22) v2(158.02,122.49) v2(158.02,121.85) v2(158.02,121.22) v2(158.66,122.49) v2(158.66,121.85) v2(158.66,121.22) v2(158.66,120.58) v2(159.29,122.49) v2(159.29,121.85) v2(159.29,121.22) v2(159.29,120.58) v2(198.47,40.51) v2(199.11,40.51) v2(199.74,40.51) v2(200.38,40.51) v4(131.23,138.06)
+5VALWP: length 31
  TOP w0.102: v2(162.7,136.84) 162.15,136.29 v4(162.15,136.18)
  IN2 w0.254: v2(160.63,137.28) 162.47,135.44 162.47,127.44 160.82,125.79 v2(160.82,124.96) ; v2(162.7,136.84) 163.1,136.43 163.1,127.31 161.39,125.6 161.39,124.77 v2(160.82,124.2)
  BOTTOM w0.254: PR510.1 161.44,137.44 PR509.2 162.28,137.42 162.7,137 v2(162.7,136.84) ; PU501.14 160.51,137.4 v2(160.63,137.28)
  vias: v2(155.86,126.17) v2(155.86,125.41) v2(155.86,124.39) v2(155.86,123.63)
+5VS: length 176.7
  TOP w0.508: v2(82.97,31.87) 82.97,30.54 85.63,27.87 F3.2 87.82,24.99 v2(88.88,23.92) ; RA4.1 v2(21.05,24.89)
  IN1 w0.508: v2(43.19,28.48) 41.93,28.48 40.5,27.05 34.56,27.05 33.61,26.09 24.67,26.09 23.47,24.89 v2(21.05,24.89)
  IN2 w1.524: 131.16,143.7 129.23,141.77 124.07,141.77 119.03,146.81 92.74,146.81 90.59,148.97 79.03,148.97 76.04,145.98 76.04,137.16 72.17,133.28 53.88,133.28 47.21,126.61 38.77,126.61 35.85,123.69 35.85,120.65 24.99,109.79
  BOTTOM w0.508: v2(82.97,31.87) 83.54,32.44 83.54,32.99 84.5,33.96 Q7.3
  vias: v2(22.32,108.83) v2(22.98,108.83) v2(23.59,108.83) v2(34.01,2.15) v2(34.01,1.52) v2(34.64,2.15) v2(34.64,1.52) v2(38.64,19.87) v2(38.64,19.24) v2(39.28,19.87) v2(39.28,19.24) v2(129.44,135.06) v2(129.44,134.42) v2(129.44,133.79) v2(129.44,133.15) v2(130.07,135.06) v2(130.07,134.42) v2(130.07,133.79) v2(130.07,133.15) v2(130.66,135.06) v2(130.66,134.42) v2(130.66,133.79) v2(130.66,133.15) v2(131.24,135.06) v2(131.24,134.42) v2(131.24,133.79) v2(131.24,133.15) v2(132.37,144.01) v2(132.37,143.38) v2(133,144.01) v2(133,143.38) v2(133.62,144.01) v2(133.62,143.38) v2(134.25,144.01) v2(134.25,143.38) v2(134.89,144.01) v2(134.89,143.38) v2(135.47,144.01) v2(135.47,143.38) v2(136.06,144.01) v2(136.06,143.38) v2(179.61,39.1) v2(180.31,39.1) v2(181.03,68.23) v2(181.01,39.1) v2(181.26,67.65) v2(181.66,68.21) v2(181.71,39.1) v2(210.22,31.05) v2(210.22,30.41) v2(210.85,31.05) v2(210.85,30.41) v2(211.49,31.05) v2(211.49,30.41) v2(216.75,28.75) v2(218.98,29.14) v2(218.98,28.51) v2(219.62,29.14) v2(219.62,28.51) v2(222.16,42.59) v2(222.16,41.95) v4(134.83,135.34)
+5VS_ODD:
  vias: v2(193.81,65.71) v2(194.51,65.71) v2(195.14,65.71) v4(192.54,63.69)
+17.4V_BATT+: length 55.7
  TOP w0.102: PCB19.1 v4(175.26,51.57)
  TOP w0.254: v2(176.18,43.49) 176.18,40.79 173.68,38.29 PRB28.2 173.45,38.28 PQB08.3
  IN1 w0.254: v2(176.18,43.49) 176.94,43.49 178.89,41.55 187.69,41.55 187.81,41.67 194.03,41.67 196.74,44.38 201.2,44.38 201.61,44.79 201.61,45.38 204.53,48.3 204.53,53.31 203.42,54.41 202.18,54.41 v2(199.4,57.2)
  BOTTOM w0.254: PRB10.1 198.64,56.43 v2(199.4,57.2)
  vias: v2(174.47,50.22) v2(174.47,49.53) v2(174.47,48.45) v2(174.47,47.75)
+17.4V_BATT++: length 24.9
  TOP w2.032: 159.45,42.35 172.12,42.35
  BOTTOM w2.032: 159.42,42.35 171.61,42.35
  vias: v2(155.86,41.97) v2(155.86,41.33) v2(156.5,41.97) v2(156.5,41.33) v2(157.26,41.97) v2(157.26,41.33) v2(158.02,41.97) v2(158.02,41.33) v2(172.44,46.22) v2(172.44,45.59) v2(172.44,44.95) v2(172.44,44.32) v2(173.07,46.22) v2(173.07,45.59) v2(173.07,44.95) v2(173.07,44.32) v4(156.63,42.81) v4(173.69,42.88) v4(173.8,45.8)
+19V_ADPIN:
  vias: v2(92.11,144.46) v2(92.11,143.82) v2(92.74,145.09) v2(92.74,144.46) v2(92.74,143.82) v2(93.38,145.09) v2(93.38,144.46) v2(93.38,143.82) v4(92.39,145.52) v4(92.41,143.31) v4(92.79,147.4)
+19VB: length 112.1
  TOP w1.524: 201.58,55.88 191.3,55.88 188.73,53.31 184.59,53.31 183.8,54.1
  BOTTOM w0.508: 108.97,146.93 109.25,146.66 PR302.2
  BOTTOM w3.048: 143.07,146.2 142.34,146.93 100.94,146.93 99.03,145.03 ; 166.4,118.25 166.4,143.19 162.66,146.93 149.68,146.93 149.06,146.31
  vias: v2(98.97,141.35) v2(98.97,140.71) v2(98.97,140.08) v2(144.69,144.01) v2(145.32,144.01) v2(145.96,144.01) v2(146.59,144.01) v2(147.61,143.95) v2(148.24,143.95) v2(148.88,143.95) v2(149.51,143.95) v2(150.15,143.95) v2(178.47,56.45) v2(178.47,55.81) v2(178.47,55.18) v2(178.47,54.54) v2(179.1,56.45) v2(179.1,55.81) v2(179.1,55.18) v2(179.1,54.54) v2(203.23,57.4) v2(203.23,56.76) v2(203.23,56.13) v4(202.73,55.51)
+19VB_1.2V: length 40.3
  TOP w0.254: v2(93.76,141.41) 93.76,141.85 93.38,142.24 90.88,142.24 90.6,141.96 89.76,141.96 89.48,142.24 83.6,142.24 81.44,140.08 81.44,128.39 82.39,127.44 87.16,127.44 v1(87.92,126.68) 92.87,126.68 v2(93.76,127.57)
  BOTTOM w0.254: PRM07.1 93.56,127.77 v2(93.76,127.57)
  vias: v2(94.4,141.41) v2(95.03,141.41)
+19VB_+1VALW: length 0.6
  TOP w0.102: v2(172.69,54.67) v1(173.25,54.67)
  vias: v2(172.06,54.67)
+19VB_CPU: length 27.6
  TOP w0.508: v2(151.42,104.88) 152.29,104.01 159.61,104.01 161.16,102.46 161.16,98.81 161.68,98.29 PCI26.1
  BOTTOM w0.508: PRZ35.1 146.47,108.58 146.34,108.45 146.34,105.75 147.2,104.88 v2(151.42,104.88)
  vias: v1(160.42,88.93) v2(160.88,95.61) v2(160.88,94.97) v2(160.88,94.34) v2(160.88,93.7) v2(160.88,93.09) v2(161.26,85.51) v2(161.26,84.81) v2(161.26,84.18) v2(161.26,83.54) v2(161.26,82.91) v2(163.94,74.94) v2(164.58,74.94) v2(165.39,74.95) v2(166.21,74.95)
+VCC_CORE: length 3
  BOTTOM w0.152: v2(137.17,84.74) UC1.A44
  BOTTOM w0.203: v2(136.87,77.54) 136.64,77.31 UC1.A30 ; UC1.A34 136.87,79.79 v2(136.87,79.78) ; UC1.A39 136.7,82.26 v2(136.86,82.1)
  vias: v2(119.96,81) v2(119.96,80.08) v2(119.96,79.17) v2(119.96,78.25) v2(121.45,81.94) v2(121.7,80.39) v2(121.7,79.78) v2(121.7,78.56) v2(122.05,81.94) v2(122.89,77) v2(123,82.32) v2(123.33,83.71) v2(123.43,81.04) v2(123.43,79.77) v2(123.43,78.5) v2(123.7,82.32) v2(124.09,77) v2(124.46,82.32) v2(124.6,83.71) v2(124.94,79.34) v2(125.13,83.35) v2(125.22,84.04) v2(125.16,82.7) v2(125.16,82) v2(125.3,76.3) v2(125.61,84.67) v2(125.71,83.35) v2(125.85,86.12) v2(125.92,84.04) v2(126.04,80.79) v2(126.19,79.34) v2(126.3,84.67) v2(126.3,83.4) v2(126.62,84.04) v2(126.57,76.3) v2(126.67,82.06) v2(127,83.4) v2(127.32,84.04) v2(127.41,79.34) v2(127.7,83.4) v2(127.84,84.72) v2(127.84,76.3) v2(128.02,84.04) v2(128.34,83.4) v2(128.34,82.82) v2(128.63,79.34) v2(128.72,84.04) v2(128.74,82.38) v2(128.92,83.4) v2(129.11,76.3) v2(129.29,82.69) v2(129.29,82.06) v2(129.55,80.79) v2(129.82,79.34) v2(129.94,82.69) v2(129.88,82.05) v2(130.38,76.3) v2(130.54,82.61) v2(130.49,82.02) v2(131.1,84.01) v2(131.09,83.31) v2(131.12,82.53) v2(131.1,81.28) v2(131.1,80.64) v2(131.1,80.01) v2(131.1,79.37) v2(131.1,78.74) v2(132.83,82.84) v2(132.84,81) v2(132.8,79.13) v2(132.85,77.34) v2(144.18,95.31) v2(144.18,88.26) v2(144.3,91.82) v2(144.81,88.26) v2(144.89,91.82) v2(145.45,88.26) v2(145.47,93.72) v2(145.47,93.09) v2(145.47,92.45) v2(145.47,91.82) v2(146.06,93.72) v2(146.06,93.09) v2(146.06,92.45) v2(146.06,91.82) v2(146.08,88.26) v2(146.72,88.26) v2(146.94,93.72) v2(146.94,93.09) v2(146.94,92.45) v2(147.35,88.26) v2(147.99,95.88) v2(147.99,93.66) v2(147.99,92.51) v2(147.99,88.9) v2(147.99,88.26) v2(148.05,94.8) v2(148.31,95.36) v2(148.31,94.21) v2(148.31,93.07) v2(148.62,95.86) v2(148.62,93.66) v2(148.62,92.5) v2(148.62,88.9) v2(148.62,88.26) v2(148.69,94.78) v2(148.94,95.36) v2(148.94,94.21) v2(148.94,93.07) v2(149.26,95.86) v2(149.32,94.78) v2(149.26,93.64) v2(149.26,92.5) v2(149.58,95.36) v2(149.58,94.21) v2(149.58,93.07) v2(149.89,95.86) v2(149.89,93.64) v2(149.89,92.51) v2(149.96,94.78) v2(150.15,91.24) v2(150.15,90.61) v2(150.21,93.07) v2(150.21,91.93) v2(150.28,89.34) v2(150.28,88.05) v2(150.28,86.78) v2(150.28,85.51) v2(150.28,84.24) v2(150.53,92.5) v2(150.85,93.07) v2(150.85,91.93) v2(150.78,91.24) v2(150.78,90.61) v2(151.16,92.5) v2(151.48,93.07) v2(151.48,91.93) v2(151.8,92.5) v2(151.8,88.12) v2(151.8,87.48) v2(151.8,86.85) v2(151.8,86.21) v2(152.12,93.07) v2(152.12,91.93) v2(152.43,88.12) v2(152.43,87.48) v2(152.43,86.85) v2(152.43,86.21) v2(153.07,88.12) v2(153.07,87.48) v2(153.07,86.85) v2(153.07,86.21) v4(152.46,90.99)
+VCC_CORE_42: length 0.7
  TOP w0.102: 125.28,88.53 125.74,88.53 v1(125.92,88.35)
  vias: v2(121.48,83.72) v2(121.63,87.57) v2(121.89,88.7) v2(121.95,88.06) v2(122.26,87.52) v2(122.26,86.18) v2(122.53,88.7) v2(122.54,88.12) v2(122.97,87.69) v2(123.44,86.18)
+VCC_CORE_G0: length 1.5
  TOP w0.254: v2(130.85,77.8) 131.11,78.06 TP32.1
  BOTTOM w0.254: UC1.K32 v2(130.85,77.8)
+VCC_CORE_G1: length 1.2
  TOP w0.076: TP33.1 121.64,77.83 v2(121.78,77.98)
  BOTTOM w0.076: v2(121.78,77.98) 121.78,77.96 121.62,77.8 UC1.AK32
+VCC_GT: length 14.1
  TOP w0.254: RC155.1 132.34,101.26 131.96,101.26 131.84,101.15 131.84,100.03 131.68,99.86 ; PCG147.1 132.41,92.38 136.87,92.38 v2(137.07,92.18)
  TOP w0.381: PCG148.1 136.47,95.23 v2(137.05,94.65)
  BOTTOM w0.203: UC1.A66 136.86,97.13 137.32,97.59 v2(137.7,97.59) ; v2(137.05,94.65) UC1.A62 ; v2(137.07,92.18) UC1.A58
  vias: v2(122.89,92.62) v2(122.89,90.21) v2(123.13,94.07) v2(124.02,94.07) v2(124.16,92.62) v2(124.16,90.21) v2(124.46,95.34) v2(124.84,94.07) v2(125.37,99.89) v2(125.37,99.24) v2(125.37,98.59) v2(125.37,97.29) v2(125.37,95.99) v2(125.37,95.34) v2(125.43,92.62) v2(125.43,90.21) v2(125.8,94.07) v2(126.06,107.09) v2(126.05,105.87) v2(126.05,104.6) v2(126.05,103.33) v2(126.06,102.06) v2(126.06,100.79) v2(126.28,99.89) v2(126.28,99.24) v2(126.28,98.59) v2(126.28,97.94) v2(126.28,97.29) v2(126.28,96.64) v2(126.28,95.99) v2(126.28,95.34) v2(126.56,90.23) v2(126.75,94.07) v2(126.7,92.62) v2(127.2,99.89) v2(127.2,97.94) v2(127.2,95.99) v2(127.45,107.42) v2(127.45,106.2) v2(127.45,104.93) v2(127.45,103.66) v2(127.45,102.39) v2(127.45,101.12) v2(127.57,90.22) v2(127.7,94.07) v2(127.92,126.04) v2(127.97,92.62) v2(128.11,99.89) v2(128.11,99.24) v2(128.11,98.59) v2(128.11,97.94) v2(128.11,97.29) v2(128.11,96.64) v2(128.11,95.99) v2(128.11,95.34) v2(128.59,94.07) v2(128.69,124.9) v2(128.89,105.72) v2(128.89,104.47) v2(128.89,103.23) v2(128.89,101.96) v2(128.89,100.69) v2(129.03,99.24) v2(129.03,98.59) v2(129.03,97.29) v2(129.03,95.99) v2(129.03,95.34) v2(129.24,92.62) v2(129.45,126.04) v2(129.45,123.76) v2(129.48,94.07) v2(129.62,90.5) v2(129.62,89.23) v2(129.94,99.24) v2(129.94,98.59) v2(129.94,97.94) v2(129.94,97.29) v2(129.94,96.64) v2(129.94,95.99) v2(129.94,95.34) v2(130.34,124.9) v2(130.34,100.7) v2(130.38,94.07) v2(130.51,92.62) v2(131,93.69) v2(131,92.99) v2(131,91.91) v2(131,91.02) v2(131,90.39) v2(131.1,126.04) v2(132.24,125.28) v2(132.24,124.26) v2(132.56,126.87) v2(132.62,123.12) v2(132.62,122.11) v2(132.62,120.58) v2(133.13,125.28) v2(133.13,124.26) v2(133.38,123.12) v2(133.38,122.11) v2(133.38,120.58) v2(133.38,119.82) v2(133.83,126.87) v2(134.02,125.28) v2(134.02,124.26) v2(134.4,120.58) v2(134.4,119.82) v2(134.91,125.28) v2(134.91,124.26) v2(134.91,119.09) v2(134.91,118.3) v2(134.91,117.54) v2(135.1,126.87) v2(135.42,120.58) v2(135.42,119.82) v2(135.8,125.28) v2(135.8,124.26) v2(135.92,119.09) v2(135.92,118.3) v2(135.92,117.54) v2(136.37,126.87) v2(136.43,119.82) v2(136.69,125.28) v2(136.69,124.26) v2(136.94,119.09) v2(136.94,118.3) v2(136.94,117.54) v2(138.34,122.87) v2(139.35,122.87) v2(140.37,122.87) v4(127.01,121.22)
+VCC_GT_42: length 6.4
  TOP w0.254: PCC6.1 PCC05.1 132.99,86.06 133.68,86.06 134.1,86.48 v1(135.34,86.48) 136.13,86.48 v2(136.69,87.04)
  BOTTOM w0.203: UC1.A48 136.4,87.04 v2(136.69,87.04) ; v2(136.74,89.89) 136.55,89.7 UC1.A53
  vias: v2(127.81,87.22) v2(127.81,85.95) v2(131.07,88.29) v2(131.07,87.4) v2(131.07,86.51) v2(131.07,85.56) v2(131.07,84.73)
+VCC_GT_K52: length 3.7
  TOP w0.102: v1(133.21,90.51) 132.47,90.51 132.08,90.12 RC157.2
  TOP w0.457: v2(131.07,89.24) 131.44,89.24 131.71,89.51 RC157.2
  BOTTOM w0.254: v2(131.07,89.24) 131.21,89.23 UC1.K52
+VCC_SA: length 1.9
  TOP w0.508: v2(147.2,72.12) 147.2,71.88 146.5,71.19 RC159.1
  vias: v2(121.67,73.68) v2(121.67,72.83) v2(123.74,73.88) v2(124.94,73.88) v2(126.15,73.88) v2(128.63,73.88) v2(129.83,73.88) v2(131.1,74.82) v2(131.1,74.24) v2(131.1,73.62) v2(131.1,73.03) v2(132.85,75.51) v2(132.85,73.68) v2(138.21,75.37) v2(138.85,75.37) v2(139.48,75.37) v2(153.45,67.24) v2(153.46,66.6) v2(153.84,66.15) v2(153.83,65.53) v2(153.83,64.83) v2(154.4,66.48) v2(154.39,65.84) v2(154.4,65.21) v2(154.91,65.53) v2(154.91,64.89) v4(131.91,74)
GND: length 1845.9
  TOP w0.076: v2(150.77,33.33) 150.27,33.83 150.27,34.36 UM1.N2 150.77,34.36 v2(150.77,33.33)
  TOP w0.102: v2(212.2,35.8) 212.2,36.51 v4(212.07,36.63)
  TOP w0.152: UM1.A6 144.49,36.64 144.21,36.64 143.77,37.09 v2(143.77,37.25)
  TOP w0.203: UM1.J5 148.52,36.4 v2(148.38,36.54) ; UM1.E7 146.54,37.11 v2(146.95,37.52) ; v2(151.49,36.61) UM1.P6 UM1.N5 UM1.P4 ; v2(149.46,37.63) 149.02,37.63 149.02,37.62 UM1.K8 ; UE1.51 42.4,62.59 42.1,62.89 v2(41.72,62.89) ; UM1.G5 147.52,35.65 v2(147.54,35.62) ; UM1.E9 v2(147.02,38.11) UM1.F10 UM1.E10 ; UM1.H10 148.02,38.28 v2(147.86,38.11) ; v2(47.98,70.83) UE1.84 ; v2(36.54,78.47) 36.8,78.21 UE1.124 ; UE1.17 32.27,69.23 v2(32.2,69.3) ; v2(46.51,75.65) 46.51,76.32 46.4,76.42 UE1.100 ; v2(146.05,36.44) 146.05,36.13 145.53,35.61 UM1.C4 ; UE1.64 v2(47.6,60.36) ; UZ3.11 v2(126.97,133.71)
  TOP w0.254: v2(201.85,47.11) PCB31.2 ; v2(119.31,80.08) 119.31,80.26 119.59,80.54 ; v2(216.89,53.64) 216.64,53.89 RP1.3 ; v2(216.89,53.64) 216.89,53.06 216.71,52.89 RP1.1 ; v2(216.89,53.64) 216.64,53.39 RP1.2 ; US1.6 v2(189.4,43.75) ; PCI140.2 120.17,80.54 ; US1.7 188.84,43.53 v2(188.63,43.75) ; v2(190.15,43.75) 189.9,43.49 189.89,43.49 US1.5 ; PQB05.3 203.77,48.55 203.3,48.55 v2(202.9,48.15) ; v2(187.18,42.07) 187.48,41.77 US1.8
  TOP w0.305: v2(216.72,38.5) 216.97,38.75 JVGA.1 ; JDEG1.10 v2(41.5,95.05) ; JVGA.7 v2(216.75,35.75) ; CD39.2 59.3,46.08 v2(59.91,46.08) ; JVGA.4 v2(216.72,37.25)
  TOP w0.356: PCI149.2 145.45,86.8 v2(145.77,86.48) 146.08,86.8 PCI150.2 ; PCI138.2 v2(144.18,90.04) PCI146.2 ; PCI136.2 v2(145.45,90.04) PCI155.2 ; PCI154.2 v2(146.08,90.04) PCI135.2 ; v2(144.89,93.63) 144.84,93.58 144.84,93.02 PCI148.2 ; PCI153.2 147,89.44 v2(147.29,89.15) ; PCI130.2 146.72,86.8 v2(147.04,86.48) 147.35,86.8 PCI137.2 ; PCI147.2 144.31,94.03 v2(144.31,93.61) 144.31,93.12 PCI158.2 ; PCI145.2 144.18,86.8 v2(144.5,86.48) 144.81,86.8 PCI151.2 ; CC61.2 121.18,69.76 v2(120.53,69.12) ; PCI156.2 148.62,86.8 v2(148.31,86.48) 147.99,86.8 PCI152.2 ; PCI159.2 v2(144.81,90.04) PCI162.2
  TOP w0.381: v2(132.93,97.74) 132.92,97.75 RC121.2 ; PCI105.2 128.63,78.32 PCI143.2 ; UC5.3 100.06,53.97 CC10.2 ; PQ13.1 120.35,140.52 v2(120.53,140.7) ; v2(131.06,63.62) 130.16,63.62 RC5.1 ; PCG138.2 131.17,100.36 v2(130.98,100.55) ; PCI144.2 125.45,78.45 PCI113.2 ; UC2.3 v2(107.3,118.53) ; v2(121.65,140.99) PQ13.4 121.65,142.44 121.78,142.57 PR38.2 ; v2(132.85,83.74) 132.81,83.7 PCI165.2 ; JDEG1.11 v2(47,97.53) ; v2(205.46,46.54) 205.52,46.6 PQB06.3 ; PCI161.2 135.02,77.37 v2(135.09,77.31) ; CC14.2 120.36,37.89 UC6.3 ; PQ12.1 118.12,142.96 118.31,143.15 118.75,143.15 v2(119.03,143.43) ; PCI139.2 120.48,77.66 120.8,77.34 v2(121.4,77.34) ; UC7.3 144.58,103.92 v2(144.12,103.46) ; PCZ36.2 144.55,116.56 v2(144.05,116.56) ; v2(124.46,97.93) 124.46,97.93 124.17,97.65 PCG140.2 ; v2(144.05,115.93) 144.17,115.82 PRZ65.2 ; v2(124.46,96.61) 124.46,96.61 124.17,96.32 PCG136.2 ; PCI132.2 130.28,78.5 PCI103.2 ; PRH04.2 v2(166.79,50.33) ; RC122.2 132.45,95.87 v2(132.61,95.7) ; PCH10.2 168.63,50.4 v2(168.69,50.33) ; v2(153.96,29.52) 153.66,29.82 UM2.3 ; v2(59.91,46.08) 59.91,46.44 60.2,46.73 RD16.2 ; v2(150.91,51.68) 150.83,51.76 UC9.3 ; v2(34.39,81.67) 34.39,81.27 34.99,80.67 CE4.2 ; CC85.2 149.1,57.54 RC64.2 149.11,58.15 v2(149.74,58.78) ; PCG145.2 v2(132.83,92.86) ; JDEG1.12 v2(40.5,97.53) ; PCA110.2 132.59,76.07 v2(132.85,76.33) 132.42,76.76 PCI160.2 ; v2(132.9,93.83) 132.89,93.82 132.5,93.82 PCG144.2 ; PCI142.2 121.69,80.99 v2(121.7,81) ; v2(132.83,81.91) 132.86,81.89 PCI157.2 ; v2(121.7,79.17) 121.68,79.15 PCI134.2 ; PCG139.2 124.17,98.96 124.46,99.24 v2(124.46,99.25) ; v2(130.92,97.3) 131.23,97.62 PCG143.2 ; RD5.2 74.73,45.63 75.37,45.63 76.23,44.76 v2(76.23,44.75) ; v2(132.84,80.08) 132.77,80.01 PCI131.2 132.11,80.17 PCI164.2 ; PCI141.2 127.04,77.95 PCI111.2
  TOP w0.406: UE2.3 49.48,57.1 49.61,56.97 RE53.1 ; v2(122.25,77) 122.25,76.59 PCI125.2 ; PQ12.4 v2(116.82,141.29)
  TOP w0.432: QS1.1 188.06,36.7 188.2,36.84 v2(188.2,37.98) ; v2(190.66,34.79) 190.61,34.84 QS1.4
  TOP w0.457: PCA101.2 124.36,74.28 v2(124.36,73.88) ; PCI123.2 123.48,76.57 v2(123.48,77) ; PCG133.2 125.64,103.96 v2(126.05,103.96) ; PCI107.2 129.75,75.9 v2(129.75,76.3) ; v2(123.52,92.62) 123.52,92.22 PCG128.2 ; PCI102.2 123.84,81.67 v2(123.43,81.67) ; v2(121.68,86.18) 121.68,85.47 PCC01.2 ; v2(123.52,90.21) 123.52,89.8 PCG129.2 ; CE13.2 40.52,81.14 v2(40.68,81.31) ; v2(128.48,76.3) 128.48,75.9 PCI108.2 ; v2(129.62,91.14) 129.21,91.14 PCG121.2 ; v2(129.55,81.42) 129.15,81.42 PCI104.2 ; CC45.2 119.31,76.98 v2(119.31,77.34) ; v2(127.84,85.35) 127.46,85.35 PCI106.2 ; v2(126.8,79.34) 126.8,78.93 PCI112.2 ; PCG120.2 127.33,92.22 v2(127.33,92.62) ; CZ23.2 127.91,138.94 v2(127.21,138.94) ; CC75.2 132.23,65.44 v2(132.87,65.44) ; CC86.2 123.06,61.02 v2(123.09,61.05) ; PCG124.2 125.64,101.42 v2(126.06,101.42) ; v2(128.6,92.62) 128.6,92.22 PCG107.2 ; PCI115.2 124.67,75.9 v2(124.67,76.3) ; PCI117.2 123.84,79.13 v2(123.43,79.13) ; v2(127.21,76.3) 127.21,75.9 PCI114.2 ; v2(123.99,68.7) 124.31,68.7 124.44,68.56 CC57.2 ; v2(123.99,83.71) 123.99,84.14 PCI109.2 ; v2(129.24,79.34) 129.24,78.93 PCI105.2 ; v2(126.04,81.42) 126.44,81.42 PCI122.2 ; v2(158.34,114.82) 158.34,115.42 157.88,115.88 PRZ01.2 157.63,115.87 PCZ03.2 ; PCG116.2 124.79,92.22 v2(124.79,92.62) ; v2(213.32,42.22) 213.55,42.22 213.86,42.54 C16.2 ; PCI118.2 123.84,80.4 v2(123.43,80.4) ; v2(126.06,92.62) 126.06,92.22 PCG117.2 ; PCI113.2 125.58,78.93 v2(125.58,79.34) ; v2(125.57,73.88) 125.57,74.28 PCA102.2 ; RE62.2 v2(42.17,90.58) ; PCA105.2 129.25,74.28 v2(129.25,73.88) ; v2(122.86,86.18) 122.86,85.5 PCC02.2 ; PCG111.2 125.64,102.69 v2(126.06,102.69) ; CE33.2 33.59,81.28 v2(33.58,81.29) ; CE12.2 46.42,81.45 v2(46.42,81.75) ; PCG130.2 129.21,89.87 v2(129.62,89.87) ; v2(126.53,138.66) 126.39,138.8 CZ25.2 ; v2(128.04,73.88) 128.04,74.28 PCA109.2 ; CE11.2 53.41,69.24 v2(53.85,68.8) 53.41,68.35 RE19.2 ; RC136.1 133.47,100.78 v2(134.22,100.78) ; PCG110.2 129.87,92.22 v2(129.87,92.62) ; PCI110.2 122.72,84.14 v2(122.72,83.71) ; v2(40.9,85.12) 40.64,84.86 RE32.2 ; PCI121.2 126.46,86.42 v2(126.46,86.12) ; v2(127.86,131.42) 127.9,131.46 CZ10.2 CZ9.2 ; v2(126.05,106.5) 125.64,106.5 PCG127.2 ; v2(127.34,71.87) 127.42,71.95 CC58.2 ; CC46.2 119.39,81.81 v2(119.31,81.89) ; v2(124.79,90.21) 124.79,89.8 PCG122.2 ; v2(126.08,131.42) 126.4,131.74 CZ11.2 CZ12.2 ; v2(122.25,90.21) 122.25,89.8 PCG126.2 ; v2(126.67,82.69) 127.08,82.69 PCI101.2 ; v2(125.64,70.7) 124.9,70.7 CC62.2 ; v2(123.15,73.88) 123.15,74.28 PCA104.2 ; PCG131.2 122.25,92.22 v2(122.25,92.62) ; v2(128.02,79.34) 128.02,78.93 PCI111.2 ; CE14.2 39.51,79.42 v2(39.18,79.08) ; v2(122.72,64.96) 122.48,65.19 CC68.2 ; CC50.2 120.31,86.48 v2(119.89,86.48) ; v2(126.05,105.23) 125.64,105.23 PCG118.2 ; v2(130.46,79.34) 130.46,79.11 130.15,78.81 PCI103.2 ; PCI116.2 125.94,75.9 v2(125.94,76.3)
  TOP w0.508: C12.2 C2.2 v2(217.4,58.67) ; CL20.2 30.01,84.77 v2(30.32,84.45) 30.32,83.88 30.07,83.62 CL25.2 ; v2(96.3,148.08) 96.44,148.22 PC3.2 ; v2(122.08,54.75) 122.02,54.81 122.02,55.11 121.51,55.62 CC52.2 CC51.2 ; PRB36.2 202.12,48.71 v2(202.33,48.5) ; C14.2 215.55,48.76 v2(215.62,48.83) ; v2(145.07,76.23) 145.16,76.32 CC77.2 ; v2(29.07,74.61) 29.33,74.86 CE6.2 ; v2(135.73,126.87) 135.73,127.25 136.05,127.57 ; v2(61.31,44.95) 60.79,44.43 RD17.2 ; RD18.2 57.5,67.06 57.32,67.23 v2(56.96,67.23) ; Q24.3 54.14,25.98 v2(54.29,25.83) ; v2(77.24,77.98) 77.24,77.98 CD14.2 CD12.2 ; CE26.2 50.55,57.8 v2(50.87,57.48) ; CL23.2 v2(25.56,90.99) 26.27,90.99 RL4.2 ; CC9.2 103.18,59.25 103.43,59.5 v2(103.43,59.51) ; PCB28.2 204.57,45.02 v2(204.38,44.83) ; RA17.2 v2(12.8,3.61) ; v2(153.07,65.65) 151.91,65.65 151.55,66.02 CZ21.2 CZ1.2 ; v2(131.92,126.87) 131.92,127.25 132.24,127.57 ; CC78.2 125.3,67.74 v2(125.62,68.06) ; v2(146.11,99.31) 146.12,99.32 CC13.2 ; v2(31.47,6.57) 31.38,6.66 CA2.2 ; CD52.2 57.08,98.61 v2(56.96,98.49) ; v2(134.46,126.87) 134.46,127.25 134.78,127.57 ; C34.2 EC3002.2 95.42,33.15 v2(95.43,33.16) ; CC12.2 C35.2 125.46,37.73 v2(125.57,37.84) ; v2(128.89,105.11) 129.29,105.11 PCG112.2 ; CW8.2 CW7.2 66.52,121.34 v2(66.39,121.22) ; PD1.1 v2(82.08,142.55) ; v2(122.31,71.27) 122.36,71.32 CC55.2 ; v2(93.19,148.08) 93.36,148.25 PC2.2 ; CA38.1 v2(38.72,12) ; v2(146.38,70.4) 146.24,70.4 146.18,70.34 CC44.2 CC41.2 ; CZ8.2 v2(145.27,49.08) ; v2(149.45,72.83) 149.45,72.77 149.93,72.29 CC76.2 ; v2(29.5,62.54) RE68.2 RE20.2 ; v2(146.4,122.49) 146.72,122.17 PRZ55.2 ; v2(128.89,102.59) 129.29,102.59 PCG115.2 ; CM4.2 CM3.2 v2(156.7,34.46) ; v2(198.47,44.89) 198.55,44.97 PRB26.2 ; CL19.2 v2(25.56,91.88) ; v2(18.32,80.7) CL24.2 ; RC197.2 117.57,41.19 v2(118.29,40.48) ; CZ5.2 151.13,59.97 v2(151.69,59.97) ; CC42.2 146.7,73.5 CC83.2 v2(147.51,74.18) ; CC8.2 106.43,58.7 v2(106.52,58.8) ; v2(25.66,1.5) 25.39,1.5 CA30.2 ; CS29.2 193.47,40.62 193.99,40.1 CS30.2 v2(194.47,39.24) ; v2(146.68,78.79) 146.68,78.88 147.1,79.29 RC151.2 ; EC2902.2 218.67,62.89 v2(218.41,63.15) ; v2(53.57,64.61) CE31.2 RE16.2 ; PRB43.2 185.28,65.26 185.15,65.39 v2(185.12,65.39) ; CW3.2 CW4.2 72.3,127.31 v2(72.55,127.56) ; CW9.2 v2(72.93,138.87) ; CC91.2 94.84,51.18 94.59,50.92 v2(94.59,50.6) ; CE10.2 v2(53.62,60.16) ; v2(125.81,57.57) 125.66,57.72 RC52.2 ; PR44.1 115.25,143.82 v2(114.97,144.1) ; CL11.2 v2(20.75,84.98) ; PCZ24.2 v2(154.59,121.66) ; CA3.2 v2(35.29,6.03) ; PCG123.2 129.29,101.32 v2(128.89,101.32) ; Q4.3 v2(54.1,50.54) ; RC94.1 99.12,58.38 v2(97.86,58.38) 97.57,58.08 CC11.2 ; CD19.2 70.41,72.25 v2(69.72,72.95) 69,72.22 CD43.2 ; v2(36.74,16.95) 36.64,17.05 CA6.2 CA17.2 ; v2(21.56,5.77) 21.31,6.03 EC3003.2 20.87,6.52 19.62,7.78 DA5.1 ; v2(212.72,35.24) 212.43,34.95 RC196.1 ; v2(211.25,43.54) 211.36,43.43 U3.2 ; CA4.2 v2(34.69,7.87) ; R40.2 C19.2 116.55,29.53 116.59,29.57 v2(116.59,30.23) ; C3.2 214.95,55.72 v2(214.79,55.56) ; C39.2 52.03,30.62 v2(51.42,31.22) ; v2(121.67,72.09) 122.22,72.09 CC63.2 ; v2(172.18,53.46) 172.17,53.48 PCH09.2 ; v2(39.18,57.38) CE9.2 CE28.2 ; v2(150.28,86.15) 150.66,86.15 PCI124.2 ; CL15.2 v2(20.61,92.01) ; PC4.2 98.38,148.22 v2(98.65,147.95) ; v2(36.79,14.74) 36.67,14.63 CA22.1 ; PCG132.2 129.29,103.86 v2(128.89,103.86) ; CM7.2 149.84,29.37 v2(149.89,29.32) ; CA28.2 27.69,5.95 CA13.1 27.37,6.14 26.86,5.63 v2(26.7,5.63) ; v2(18.84,27.36) 19.17,27.03 CS26.2 ; CE22.2 v2(47.12,57.7) ; v2(93.82,29.16) 93.63,29.35 R27.2 ; v2(133.19,126.87) 133.19,127.25 133.51,127.57 ; CW6.2 v2(72.93,137.73) ; v2(209.46,48.37) 209.46,47.86 C31.2 ; CZ4.2 CZ7.2 151.52,61.14 v2(151.67,60.99) ; v2(121.34,54.67) 120.98,54.31 CC54.2 120.32,54.49 CC53.2 ; CX6.2 114.26,41 v2(114.18,40.92) ; CC72.2 130.17,60.32 CC87.2 129.23,60.32 128.61,60.94 v2(128.61,61.07) ; PR6.2 v2(86.09,146.31) ; v2(134.17,96.79) 134.17,96.43 PCG148.2 ; v2(174.05,37.59) 174.33,37.31 PQB07.3 ; v2(168.18,38.59) 167.53,38.59 PD6.1 ; RC58.2 v2(125.03,41.54) ; CA27.2 31,5.8 v2(31.47,5.33) ; CA40.2 CA9.2 v2(39.34,10.98) ; v2(118,61.08) 118.43,60.65 RC8.2 118.46,60.46 CC56.2 ; CZ2.2 v2(143.77,66.19) ; v2(37.04,11.47) 36.69,11.82 RA9.2 ; v2(205.75,53.91) 205.3,54.35 PCB12.2 PRB14.2 ; v2(64.86,44) 65.12,43.74 CD38.2 CD37.2 ; C1.2 90.84,40.44 91.7,41.31 v2(92.36,41.31) ; v2(73,128.07) 73.44,127.63 CW5.2 ; v2(53.34,79.78) 53.98,79.15 DE1.2 53.48,78.45 CE17.2 ; PQ11.3 v2(28.12,61.03) ; RC160.2 145.89,72.14 v2(146.54,72.14) ; CS35.2 v2(37.25,31.73) ; R2.2 107.86,37.35 107.66,37.15 v2(107.65,37.15) ; v2(150.28,83.61) 150.66,83.61 PCI128.2 ; v2(102.16,116.01) CC1.2 ; EC2302.2 v2(26.4,24.9) ; PCG11.2 143.43,128.81 v2(143.16,129.08) ; PR45.2 v2(119.62,139.07) ; v2(95.67,148.08) 95.49,148.25 PC1.2 ; CD35.2 67.53,46.99 v2(67.69,46.83) ; CL8.2 v2(22.89,92.13) ; CD28.2 RD12.2 ; PCI119.2 150.66,87.42 v2(150.28,87.42) ; C15.2 v2(216.63,48.83) ; RC130.2 126.54,61.69 RC66.2 126.12,62.14 126.02,62.03 v2(125.79,62.03) ; v2(127.81,86.59) 127.46,86.59 PCC04.2 ; v2(127.81,87.86) 127.46,87.86 PCC03.2 ; v2(20.1,1.42) 20.1,2.33 DA2.1 ; RA24.2 v2(34.15,21.39) ; DA1.1 19.27,2.52 v2(19.27,1.44) ; v2(150.28,84.88) 150.66,84.88 PCI126.2 ; v2(44.13,57.87) CE15.2 44.14,58.5 RC224.1 ; CS25.2 v2(38.01,24.29) ; PCZ30.2 145.67,121.22 v2(145.44,121.45) ; PQ2.3 v2(86.53,144.21) ; RC211.2 101.25,55.94 v2(101.76,56.45) ; Q8.3 v2(91.17,31.94) ; v2(49.11,55.69) 49.61,56.19 RE53.1 ; v2(20.74,87.33) 20.42,87.65 CL10.2 ; CA14.2 25.32,5.57 v2(25.62,5.27) ; v2(37.3,79.18) 37.32,79.18 37.72,79.59 CE3.2 ; PCC6.2 PCC05.2 132.81,84.69 v2(132.85,84.66) ; ED2901.1 v2(221.2,66.59) ; C40.2 R75.2 56.68,29.05 v2(57.05,28.68) ; CC33.2 117.99,84.52 v2(118.09,84.61) ; v2(18.64,82.88) RL2.1 ; v2(44.78,56.92) 44.96,56.73 CE35.1 ; SW1.2 v2(225.16,61.99) ; CX7.2 114.26,39.48 v2(114.18,39.4) ; v2(18.97,105.04) 19.89,104.12 QI1.3 ; v2(29.5,61.65) CE16.2 30.18,60.76 PR43.2 ; RA18.2 v2(11.97,3.61) ; CD51.2 v2(60.05,87.56) ; R45.2 v2(54.5,55.89) ; C5.2 v2(216.44,60.89) ; CE32.1 32.37,78.83 v2(32.15,79.05) ; YL1.2 v2(16.2,84.07) ; CA5.1 v2(36.61,18.89) ; RE50.1 44.39,85.08 v2(44.66,85.35) ; JVGA.18 221.25,31.02 v2(221.65,31.42) ; v2(119.54,38.1) 119.93,37.7 CC14.2 ; UL2.2 v2(25.69,98.67) ; v2(150.28,88.7) 150.66,88.7 PCI127.2 ; v2(64.05,28.66) 64.05,29.31 63.71,29.65 C38.2 ; EC2301.2 v2(18.07,19.87) ; CE19.2 v2(51.28,61.95) ; v2(132.84,90.97) 132.7,91.11 PCG147.2 ; PR40.2 v2(115.58,139.67) ; CA16.2 v2(35.85,7.23) ; CE5.2 v2(40.23,86.2) ; RC182.2 120.94,41.36 121.28,41.02 121.96,41.02 122.32,40.66 122.32,40.59 122.34,40.57 v2(122.34,40.13) ; PD3.2 v2(91.26,146.21) ; C4.2 v2(217.08,59.75) ; EU2604.1 18.68,31.95 v2(18.3,31.57) ; v2(31.72,64.89) 31.29,64.47 CE23.2 RE48.2 ; v2(70.74,43.93) 69.85,43.93 CD6.2 ; v2(100.38,52.07) 100.38,52.07 RC102.2 CC10.2 ; EC2901.2 v2(223.52,64.72) ; CA15.1 v2(37.88,7.42) ; v2(128.89,106.33) 129.34,106.33 PCG108.2 ; Q13.3 v2(106.22,28.2) ; CL9.2 v2(28.42,102.55) ; CA29.2 24.1,4.75 v2(23.91,4.95) ; v2(34.58,3.93) CA1.2 ; v2(130.92,95.35) 131.6,94.67 RC134.2 ; RC156.2 131.57,103.97 v2(131.61,104.01) ; v2(109.32,37.15) 109.32,37.15 109.77,37.6 Q1.3 ; CL7.2 v2(18.65,81.85) ; EC3001.2 92.16,31.64 v2(91.86,31.94) ; v2(207.74,57.6) PQB04.3 ; v2(213.33,44.95) 213.33,45.54 212.43,46.44 R72.2 ; CL22.2 v2(25.56,90.1) ; R10.2 222.87,59.48 v2(222.47,59.48) C17.2 ; JVGA.17 221.25,39.68 v2(221.34,39.58) ; PD5.1 v2(161.83,35.3) ; CI9.2 v2(15.91,105.09) ; CL5.2 v2(18.64,83.96) ; v2(125.91,66.33) 126.19,66.33 CC82.2 ; PD2.2 v2(88.63,147.05) ; PCB29.2 v2(202.73,44.83) ; U1.2 v2(221.01,56.62) ; RC54.2 v2(103.03,52.89) ; YL1.4 v2(17.9,88.6) ; DA7.1 v2(17.05,20.32) ; RL6.1 v2(28.42,101.66) ; CS27.2 v2(35.86,24.34) ; C36.2 v2(145.24,103.23) ; CS36.2 v2(18.7,25.92) ; CE8.1 v2(40.9,85.12) ; CA25.1 v2(24.27,10.73) ; RA22.2 v2(18.49,22.58)
  VCC w0.254: JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 11.51,93.89 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.88,25.08 ; JUSB2.4 16.41,25.22 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.88,26.42 ; JUSB2.4 15.35,26.28 ; JUSB2.4 16.55,25.75 ; JUSB2.4 15.35,25.22 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 11.51,100.81 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 11.72,37.98 ; JUSB2.12 15.28,37.98 ; 44.01,132.29 H12.1 ; H12.1 44.01,129.31 ; H12.1 45.5,128.77 ; H12.1 46.99,129.31 ; H12.1 47.53,130.8 ; H12.1 45.5,132.83 ; H12.1 46.99,132.29 ; H12.1 43.47,130.8 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 13.18,95.85 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 12.14,95.39 ; JHDMI1.8 12.02,95.85 ; H1.1 8.27,129.08 ; H1.1 8.78,130.5 ; H1.1 6.85,132.43 ; H1.1 6.85,128.57 ; H1.1 5.43,131.92 ; H1.1 5.43,129.08 ; H1.1 4.92,130.5 ; H1.1 8.27,131.92 ; H2.1 9.83,85.8 ; H2.1 7.9,87.73 ; H2.1 6.48,84.38 ; H2.1 5.97,85.8 ; H2.1 9.32,84.38 ; H2.1 6.48,87.22 ; H2.1 7.9,83.87 ; H2.1 9.32,87.22 ; 13.5,44.42 JUSB1.10 ; JUSB1.10 11.72,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 15.28,44.42 ; JUSB1.10 15.28,46.18 ; JLAN1.9 10.65,83.22 ; JLAN1.9 9.47,83.22 ; JLAN1.9 9.47,82.55 ; JLAN1.9 11.83,83.22 ; JLAN1.9 11.83,82.55 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 12.75,103.17 ; JHDMI1.20 14.03,105.03 ; 6.4,20.52 JUSB2.11 ; JUSB2.11 5.71,20.52 ; JUSB2.11 7.77,20.52 ; H8.1 8.42,111.08 ; H8.1 6.9,114.68 ; H8.1 6.9,110.52 ; H8.1 5.38,111.08 ; H8.1 8.98,112.6 ; H8.1 5.38,114.12 ; H8.1 8.42,114.12 ; JLAN1.12 11.83,65.08 ; JLAN1.12 9.47,65.75 ; JLAN1.12 9.47,65.08 ; JLAN1.12 10.65,65.08 ; JUSB1.13 6.4,61.88 ; JUSB1.13 7.77,61.88 ; JUSB1.13 7.09,61.88 ; 12.75,88.67 JHDMI1.23 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 14.03,90.53 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 11.47,88.67 ; JLAN1.10 4.03,83.22 ; JLAN1.10 4.03,82.55 ; JLAN1.10 3.44,83.22 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 4.58,106 ; JHDMI1.21 4.58,106.46 ; 11.72,61.88 JUSB1.12 ; JUSB1.12 15.28,61.88 ; JUSB1.12 15.28,61 ; JUSB1.12 13.5,61.88 ; JUSB1.12 15.28,60.12 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 4.55,86.77 ; JUSB1.11 7.77,44.42 ; JUSB1.11 6.4,44.42 ; JUSB1.11 5.71,44.42 ; 13.5,20.52 JUSB2.10 ; JUSB2.10 15.28,22.28 ; JUSB2.10 15.28,20.52 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,20.52 ; JUSB2.13 7.09,37.98 ; JUSB2.13 7.77,37.98 ; JUSB2.13 6.4,37.98 ; 6.58,42.62 H3.1 ; H3.1 9.42,42.62 ; H3.1 6.58,39.78 ; H3.1 8,43.13 ; H3.1 6.07,41.2 ; H3.1 9.42,39.78 ; H3.1 9.93,41.2 ; H3.1 8,39.27 ; 15.35,49.12 JUSB1.4 ; JUSB1.4 15.21,49.65 ; JUSB1.4 16.55,49.65 ; JUSB1.4 16.41,50.18 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.35,50.18 ; JUSB1.4 15.88,48.98 ; JUSB1.4 15.88,50.32 ; 12.02,92.85 JHDMI1.2 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 12.14,93.31 ; JHDMI1.2 12.6,92.27 ; JHDMI1.2 13.06,92.39 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 11.51,97.81 ; JHDMI1.11 11.63,97.35 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.91,29.78 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.91,53.68 ; JUSB1.7 15.05,53.15
  GND w0.254: 5.38,114.12 H8.1 ; H8.1 8.98,112.6 ; H8.1 4.82,112.6 ; H8.1 5.38,111.08 ; H8.1 6.9,110.52 ; H8.1 6.9,114.68 ; H8.1 8.42,111.08 ; H8.1 8.42,114.12 ; JHDMI1.22 5.83,87.7 ; JHDMI1.22 3.27,86.77 ; JHDMI1.22 5.83,86.77 ; JHDMI1.22 4.55,88.63 ; JHDMI1.22 4.55,86.77 ; JHDMI1.22 3.27,88.63 ; JHDMI1.22 5.83,88.63 ; JHDMI1.22 3.27,87.7 ; JUSB1.10 15.28,46.18 ; JUSB1.10 11.72,44.42 ; JUSB1.10 11.72,45.3 ; JUSB1.10 13.5,44.42 ; JUSB1.10 15.28,45.3 ; JUSB1.10 15.28,44.42 ; 12.14,95.39 JHDMI1.8 ; JHDMI1.8 12.14,96.31 ; JHDMI1.8 12.02,95.85 ; JHDMI1.8 13.06,95.39 ; JHDMI1.8 13.06,96.31 ; JHDMI1.8 13.18,95.85 ; 10.47,100.35 JHDMI1.17 ; JHDMI1.17 10.59,100.81 ; JHDMI1.17 11.63,100.35 ; JHDMI1.17 10.59,99.89 ; JHDMI1.17 11.51,99.89 ; JHDMI1.17 11.51,100.81 ; H4.1 142.97,25.68 ; H4.1 143.48,27.1 ; H4.1 139.62,27.1 ; H4.1 141.55,29.03 ; H4.1 140.13,28.52 ; H4.1 142.97,28.52 ; H4.1 140.13,25.68 ; H4.1 141.55,25.17 ; 6.48,87.22 H2.1 ; H2.1 9.83,85.8 ; H2.1 5.97,85.8 ; H2.1 6.48,84.38 ; H2.1 7.9,87.73 ; H2.1 9.32,87.22 ; H2.1 9.32,84.38 ; H2.1 7.9,83.87 ; 10.59,97.81 JHDMI1.11 ; JHDMI1.11 10.47,97.35 ; JHDMI1.11 11.63,97.35 ; JHDMI1.11 11.51,96.89 ; JHDMI1.11 10.59,96.89 ; JHDMI1.11 11.51,97.81 ; 15.35,50.18 JUSB1.4 ; JUSB1.4 16.41,49.12 ; JUSB1.4 15.88,48.98 ; JUSB1.4 16.55,49.65 ; JUSB1.4 15.35,49.12 ; JUSB1.4 15.88,50.32 ; JUSB1.4 15.21,49.65 ; JUSB1.4 16.41,50.18 ; JUSB1.13 7.77,61.88 ; JUSB1.13 7.77,61 ; JUSB1.13 5.03,61 ; JUSB1.13 5.03,61.88 ; JUSB1.13 6.4,61.88 ; 15.88,25.08 JUSB2.4 ; JUSB2.4 16.41,26.28 ; JUSB2.4 15.21,25.75 ; JUSB2.4 15.35,25.22 ; JUSB2.4 15.88,26.42 ; JUSB2.4 15.35,26.28 ; JUSB2.4 16.41,25.22 ; JUSB2.4 16.55,25.75 ; 211.42,67.43 H13.1 ; H13.1 211.42,65.5 ; H13.1 216.28,63.57 ; H13.1 211.42,63.57 ; H13.1 213.85,63.57 ; H13.1 213.85,67.43 ; H13.1 216.28,65.5 ; H13.1 216.28,67.43 ; 135.71,108.74 HCPU2.1 ; HCPU2.1 139.05,112.07 ; HCPU2.1 137.38,108.12 ; HCPU2.1 137.38,112.69 ; HCPU2.1 139.05,108.74 ; HCPU2.1 135.71,112.07 ; HCPU2.1 139.67,110.41 ; HCPU2.1 135.1,110.41 ; 113.08,108.12 HCPU1.1 ; HCPU1.1 115.51,112.69 ; HCPU1.1 110.66,110.41 ; HCPU1.1 110.66,112.69 ; HCPU1.1 115.51,108.12 ; HCPU1.1 110.66,108.12 ; HCPU1.1 113.08,112.69 ; HCPU1.1 115.51,110.41 ; JUSB2.12 15.28,37.1 ; JUSB2.12 11.72,37.98 ; JUSB2.12 11.72,37.1 ; JUSB2.12 15.28,36.22 ; JUSB2.12 13.5,37.98 ; JUSB2.12 15.28,37.98 ; 6.07,41.2 H3.1 ; H3.1 8,43.13 ; H3.1 6.58,39.78 ; H3.1 9.42,39.78 ; H3.1 9.93,41.2 ; H3.1 9.42,42.62 ; H3.1 8,39.27 ; H3.1 6.58,42.62 ; 45.5,128.77 H12.1 ; H12.1 46.99,129.31 ; H12.1 45.5,132.83 ; H12.1 43.47,130.8 ; H12.1 44.01,129.31 ; H12.1 44.01,132.29 ; H12.1 47.53,130.8 ; H12.1 46.99,132.29 ; JLAN1.9 11.83,83.22 ; JLAN1.9 11.83,82.55 ; JLAN1.9 9.47,82.55 ; JLAN1.9 9.47,83.22 ; JLAN1.9 10.65,81.88 ; JLAN1.9 9.47,81.88 ; JLAN1.9 10.65,83.22 ; JLAN1.9 11.83,81.88 ; JLAN1.12 11.83,65.08 ; JLAN1.12 10.65,66.42 ; JLAN1.12 9.47,66.42 ; JLAN1.12 9.47,65.75 ; JLAN1.12 10.65,65.08 ; JLAN1.12 9.47,65.08 ; JUSB2.7 15.05,29.25 ; JUSB2.7 14.38,28.58 ; JUSB2.7 13.85,28.72 ; JUSB2.7 14.91,29.78 ; JUSB2.7 14.91,28.72 ; JUSB2.7 14.38,29.92 ; JUSB2.7 13.85,29.78 ; JUSB2.10 15.28,21.4 ; JUSB2.10 11.72,21.4 ; JUSB2.10 15.28,20.52 ; JUSB2.10 11.72,20.52 ; JUSB2.10 13.5,20.52 ; JUSB2.10 15.28,22.28 ; JLAN1.10 4.03,82.55 ; JLAN1.10 1.67,83.22 ; JLAN1.10 1.67,81.88 ; JLAN1.10 2.85,81.88 ; JLAN1.10 1.67,82.55 ; JLAN1.10 4.03,81.88 ; JLAN1.10 2.85,83.22 ; JLAN1.10 4.03,83.22 ; JUSB2.13 6.4,37.98 ; JUSB2.13 5.03,37.98 ; JUSB2.13 5.03,37.1 ; JUSB2.13 7.77,37.98 ; JUSB2.13 7.77,37.1 ; HCPU4.1 139.67,51.83 ; HCPU4.1 139.67,46.98 ; HCPU4.1 135.1,49.41 ; HCPU4.1 139.67,49.41 ; HCPU4.1 137.38,51.83 ; HCPU4.1 135.1,46.98 ; HCPU4.1 135.1,51.83 ; HCPU4.1 137.38,46.98 ; 6.4,44.42 JUSB1.11 ; JUSB1.11 5.03,45.3 ; JUSB1.11 7.77,45.3 ; JUSB1.11 7.77,44.42 ; JUSB1.11 5.03,44.42 ; 10.47,94.35 JHDMI1.5 ; JHDMI1.5 11.51,94.81 ; JHDMI1.5 10.59,94.81 ; JHDMI1.5 10.59,93.89 ; JHDMI1.5 11.63,94.35 ; JHDMI1.5 11.51,93.89 ; 12.14,93.31 JHDMI1.2 ; JHDMI1.2 12.6,92.27 ; JHDMI1.2 13.18,92.85 ; JHDMI1.2 12.14,92.39 ; JHDMI1.2 13.06,93.31 ; JHDMI1.2 13.06,92.39 ; JHDMI1.2 12.02,92.85 ; 11.47,89.6 JHDMI1.23 ; JHDMI1.23 11.47,88.67 ; JHDMI1.23 14.03,88.67 ; JHDMI1.23 12.75,90.53 ; JHDMI1.23 14.03,89.6 ; JHDMI1.23 11.47,90.53 ; JHDMI1.23 12.75,88.67 ; JHDMI1.23 14.03,90.53 ; 12.75,103.17 JHDMI1.20 ; JHDMI1.20 11.47,104.1 ; JHDMI1.20 11.47,105.03 ; JHDMI1.20 11.47,103.17 ; JHDMI1.20 14.03,103.17 ; JHDMI1.20 14.03,104.1 ; JHDMI1.20 12.75,105.03 ; JHDMI1.20 14.03,105.03 ; HCPU3.1 114.85,51.17 ; HCPU3.1 113.08,51.83 ; HCPU3.1 110.66,49.41 ; HCPU3.1 114.85,47.64 ; HCPU3.1 115.51,49.41 ; HCPU3.1 113.08,46.98 ; HCPU3.1 111.32,47.64 ; HCPU3.1 111.32,51.17 ; 13.85,53.68 JUSB1.7 ; JUSB1.7 13.85,52.62 ; JUSB1.7 15.05,53.15 ; JUSB1.7 14.91,53.68 ; JUSB1.7 14.38,52.48 ; JUSB1.7 14.91,52.62 ; JUSB1.7 14.38,53.82 ; 2.02,106.93 JHDMI1.21 ; JHDMI1.21 3.3,106.93 ; JHDMI1.21 3.3,105.07 ; JHDMI1.21 2.02,106 ; JHDMI1.21 4.58,105.07 ; JHDMI1.21 4.58,106 ; JHDMI1.21 4.58,106.93 ; JHDMI1.21 2.02,105.07 ; 1.67,65.08 JLAN1.11 ; JLAN1.11 2.85,66.42 ; JLAN1.11 4.03,65.75 ; JLAN1.11 1.67,66.42 ; JLAN1.11 4.03,66.42 ; JLAN1.11 1.67,65.75 ; JLAN1.11 2.85,65.08 ; JLAN1.11 4.03,65.08 ; H1.1 8.27,131.92 ; H1.1 5.43,131.92 ; H1.1 8.27,129.08 ; H1.1 6.85,132.43 ; H1.1 8.78,130.5 ; H1.1 4.92,130.5 ; H1.1 6.85,128.57 ; H1.1 5.43,129.08 ; JUSB1.12 15.28,60.12 ; JUSB1.12 11.72,61 ; JUSB1.12 15.28,61.88 ; JUSB1.12 13.5,61.88 ; JUSB1.12 11.72,61.88 ; JUSB1.12 15.28,61 ; H5.1 209.38,63.85 ; H5.1 207.45,65.78 ; H5.1 208.87,65.27 ; H5.1 205.52,63.85 ; H5.1 208.87,62.43 ; H5.1 206.03,65.27 ; H5.1 206.03,62.43 ; H5.1 207.45,61.92 ; JUSB2.11 7.77,21.4 ; JUSB2.11 7.77,20.52 ; JUSB2.11 5.03,21.4 ; JUSB2.11 5.03,20.52 ; JUSB2.11 6.4,20.52
  BOTTOM w0.102: v2(216.72,37.25) 217.22,36.75 v4(217.38,36.75) ; JKBBL1.6 88.65,31.34 v4(87.89,32.09) ; 135.94,78.65 135.88,78.65 135.69,78.84 135.39,78.84 135.37,78.82 135.06,78.82 135.04,78.84 134.8,78.84 134.78,78.82 134.47,78.82 134.14,79.15 v2(133.41,79.15) ; v4(200.62,42.88) 200.77,42.73 EU4012.1 ; v2(150.77,33.33) v4(150.77,32.3) ; JKBBL1.5 v4(97.25,35.09) ; v2(221.65,31.42) v4(222.28,31.42) ; 135.9,80.82 135.85,80.77 135.73,80.77 135.69,80.73 135.45,80.73 135.42,80.77 135.08,80.77 135.04,80.73 134.8,80.73 134.7,80.83 133.46,80.83 UC1.F37 ; PR2503.2 55.84,35.15 v4(56.5,34.5) ; PCB07.2 v4(192.64,55.5) ; v4(185.2,62.42) JODD1.1 ; UC1.C1 135.48,59.59 135.07,60 135.07,60.37 135.25,60.54 UC1.C5 ; v4(207.12,47.56) 206.79,47.56 206.42,47.93 PCB26.2 ; v2(189.4,43.75) v4(189.4,43.14)
  BOTTOM w0.127: UC1.AH6 121.99,62.32 121.83,62.16 121.51,62.16 121.32,61.97 120.74,61.97 v2(120.72,61.95) ; UC1.BB60 114.2,93.49 113.63,93.49 113.49,93.63 v2(113.03,93.63)
  BOTTOM w0.152: UC1.AG71 122.73,102.15 v2(122.56,102.32) ; v2(117.79,100.81) 117.72,100.75 UC1.AT71 ; v2(113.32,98.13) 113.6,98.13 UC1.BB67
  BOTTOM w0.178: v2(120.01,100.93) 120.01,100.83 120.06,100.78 120.06,100.18 120.06,99.91 UC1.AM71 ; v2(112.89,78.74) 112.93,78.69 114.21,78.69 UC1.BB34 ; UC1.BB26 114.23,73.73 113.48,73.73 113.44,73.69 v2(113.28,73.69) ; UC1.BB43 113.4,83.68 v2(113.37,83.7)
  BOTTOM w0.203: UC1.AL55 v2(121.45,90.14) ; UC1.AW26 116.21,73.66 116.21,74.5 116.19,74.51 UC1.AW28 ; UC1.AL58 v2(121.45,91.97) ; v2(113.11,95.86) 113.16,95.8 UC1.BB64 ; UC1.AW30 116.3,76.3 116.3,76.95 116.19,77.05 UC1.AW32 ; UC1.D48 134.21,87.22 v2(134.09,87.35) 134.09,87.59 UC1.E50 ; UC1.D48 134.81,87.22 v2(135.04,86.99) 135.26,87.22 UC1.B48 ; UC1.D48 UC1.D47 ; UC1.AW60 116.19,93.65 116.25,93.7 116.25,94.27 116.19,94.33 UC1.AW62 ; UC1.AT68 117.69,97.91 116.55,97.91 UC1.AV68 ; UC1.BB38 113.26,81.08 v2(113.22,81.04) ; UC1.AW34 116.19,79.11 116.22,79.14 116.22,79.43 116.19,79.46 UC1.AW36 116.19,80.34 116.21,80.35 116.21,80.67 116.19,80.69 UC1.AW38 116.19,81.4 v2(116.7,81.91) 116.24,82.38 UC1.AW41 116.19,82.84 116.22,82.87 116.22,83.16 116.19,83.19 UC1.AW43 ; UC1.AW6 116.15,62.73 UC1.BA6 UC1.BB6 113.54,62.73 v2(113.44,62.63) ; v2(137.32,98.29) 137.11,98.29 136.63,97.81 UC1.A67 ; UC1.BA2 114.46,60.13 114.46,59.8 114.38,59.72 UC1.BA1 114.38,59.54 113.78,58.94 113.78,58.83 v2(113.57,58.63) ; v2(121.68,86.18) 121.68,86.19 121.39,86.48 UC1.AL48 ; v2(113.41,70) 113.4,70 113.4,70.01 113.43,70.01 113.43,70 UC1.BB18 UC1.BA18 ; UC1.D44 UC1.D45 134.59,85.43 134.59,85.81 134.56,85.83 134.56,86.17 134.59,86.2 134.59,86.54 UC1.D47 ; UC1.D47 134.2,86.54 133.82,86.16 UC1.E46 ; v2(119.33,92.9) UC1.AN58 ; v2(118.67,92.87) UC1.AP58 ; v2(132.87,65.44) 132.87,65.34 UC1.G10 ; v2(113.08,75.96) 113.21,76.1 UC1.BB30 ; UC1.B14 135.5,67.33 135.16,67.33 134.69,67.4 UC1.D14 ; UC1.AV1 116.4,59.34 116,58.94 v2(116,58.45) ; PUM01.1 97.35,133.57 v2(97.44,133.66) ; UC1.AL52 v2(121.43,88.31) ; v2(132.33,100.77) UC1.H71 ; v2(135.58,59.05) UC1.C1 ; UC1.AW49 116.19,87.59 116.29,87.68 116.29,87.96 116.19,88.06 UC1.AW51 ; UC1.AH67 121.52,98.27 UC1.AK68 121.33,98.27 120.92,97.86 120.65,97.86 120.56,97.95 UC1.AM68 120.12,97.89 118.96,97.89 UC1.AP68 ; UC1.AW14 116.19,67.1 116.24,67.05 116.24,66.8 116.19,66.75 UC1.AW12 ; UC1.AW21 116.26,71.25 116.26,72 116.19,72.07 UC1.AW23 ; v2(97.51,132.65) 97.38,132.77 PUM01.3 ; UC1.G48 132.52,86.99 v2(132.85,87.32) ; UC1.BB55 114.24,90.84 113.21,90.84 v2(113.15,90.78) ; 116.49,70.58 116.19,70.28 UC1.AW18 116.19,69.62 116.21,69.61 116.21,69.07 116.19,69.05 UC1.AW16
  BOTTOM w0.254: UC1.B39 135.29,81.99 v2(134.95,81.99) 134.83,81.99 UC1.D39 ; UC1.AH67 122.16,97.57 v2(121.78,97.28) ; v2(140.12,130.69) 140.41,130.98 PUG01.2 ; v2(128.23,68.7) 128.18,68.64 128.18,68.14 UC1.T15 127.74,67.72 127.42,68.04 v2(127.35,68.04) 127.31,68.08 127.23,68.08 126.95,68.37 UC1.V16 126.83,68.46 126.83,68.93 UC1.V17 ; v2(128.23,68.7) 128.55,69.02 UC1.P17 ; v2(128.23,68.7) 128.07,68.7 UC1.T17 UC1.T18 UC1.V18 ; 135.9,80.82 138.35,80.82 139.35,79.81 ; UC1.G45 v2(132.85,84.66) UC1.G43 ; v2(125.79,62.03) 125.79,62.03 ; 125.79,62.03 125.81,62.06 125.94,62.06 126.2,62.32 UC1.W6 ; 125.79,62.03 125.78,62.03 125.78,62.02 125.74,61.99 UC1.AA4 UC1.AA2 ; UC1.P21 128.72,71.62 v2(129.02,71.32) 128.66,70.97 UC1.P20 ; UC1.AW10 116.19,64.89 v2(116.54,64.54) 116.19,64.19 UC1.AW8 ; UC1.AW10 116.36,65.15 v2(116.68,65.47) 117.03,65.11 UC1.AU10 ; UC1.AW10 UC1.BA10 ; UC1.AP32 v2(118.61,78.25) ; UC1.T21 127.51,71.87 v2(127.34,71.87) ; v2(82.14,31.87) 82.95,32.68 JKB1.30 ; UC1.D30 135.09,77.31 v2(135.09,77.31) 135.09,77.31 UC1.B30 ; UC1.W9 126.48,64.22 v2(127,64.22) ; UC1.D14 134.55,67.2 134.19,66.84 134.19,66.67 134.19,66.67 134.19,66.44 134.12,66.38 v2(134.12,66.37) 134.12,66.21 UC1.E11 134.14,65.59 UC1.D11 ; UC1.G63 132.59,95.68 v2(132.61,95.7) ; UC1.A70 UC1.B71 136.56,100.7 136.56,100.76 v2(136.6,100.8) ; UC1.AW57 116.19,92.3 116.33,92.44 116.33,93.21 UC1.AW60 ; UC1.AW57 116.19,91.76 116.27,91.68 116.27,91.34 116.19,91.26 UC1.AW55 116.19,90.48 116.24,90.43 116.24,89.71 UC1.AW53 ; UC1.AW57 116.56,92.15 v2(116.7,92) ; v2(119.95,94.71) 120.29,94.37 UC1.AM61 ; UC1.J28 132.75,76.43 v2(132.85,76.33) UC1.F28 ; UC1.AM60 120.29,93.46 v2(119.95,93.79) 120.29,94.13 UC1.AM61 ; UC1.G43 132.07,83.74 UC1.J42 ; UC1.G43 v2(132.85,83.74) UC1.F42 ; v2(130.98,100.55) UC1.K71 UC1.K70 ; UC1.B58 UC1.D58 134.38,92.18 134.12,91.92 v2(134.12,91.89) 134.12,91.77 133.87,91.51 UC1.E56 ; v2(132.85,72.77) UC1.G22 132.47,72.37 131.65,72.37 UC1.K22 ; v2(132.85,72.77) UC1.F22 ; v2(132.85,72.77) UC1.F23 ; UC1.AF4 v2(123.09,61.05) UC1.AF2 123,60.48 123,60.01 UC1.AF1 ; UC1.C25 v2(134.95,74.53) UC1.D26 ; UC1.BA14 v2(115.48,67.57) UC1.AW14 ; v2(119.31,79.17) UC1.AN33 v2(119.31,78.25) ; v2(119.31,79.17) UC1.AP35 ; v2(119.31,79.17) UC1.AN35 v2(119.31,80.08) ; UC1.F68 UC1.D69 134.28,98.54 v2(134.28,98.97) ; UC1.AV68 116.24,98.22 v2(116.24,98.33) 116.33,98.42 UC1.AV69 UC1.AV70 UC1.AV71 116.33,100.69 116.15,100.86 v2(116.08,100.86) ; UC1.F37 v2(133.5,80.08) UC1.F35 ; UC1.AK11 121.13,65.57 v2(120.84,65.87) ; v2(116.6,78.2) 117,77.8 UC1.AU32 ; v2(116.6,78.2) 116.19,77.8 UC1.AW32 115.64,77.42 ; v2(116.6,78.2) 116.19,78.6 UC1.AW34 ; UC1.AM27 UC1.AM25 119.96,73.81 v2(119.96,73.68) 119.64,73.36 UC1.AN23 UC1.AP23 UC1.AR23 118.26,73.3 117.76,73.3 UC1.AT23 ; UC1.AM27 UC1.AN28 UC1.AP28 118.66,76.45 UC1.AR28 v2(118.01,76.45) UC1.AT28 ; UC1.AM27 UC1.AK27 121.54,74.74 v2(121.7,74.74) ; v2(159.09,102.43) 159.43,102.09 PUI02.14 ; v2(132.83,81.91) UC1.J38 v2(131.08,81.91) ; v2(132.83,81.91) UC1.F40 ; v2(132.83,81.91) UC1.F38 ; v2(119.29,83.82) 119.29,83.71 ; 119.29,83.71 119.29,83.59 UC1.AP42 118.67,83.6 v2(118.67,83.83) ; 119.29,83.71 119.64,83.37 UC1.AN42 119.31,82.96 v2(119.31,82.73) 119.31,82.69 UC1.AN40 ; UC1.K61 131.59,94.73 UC1.K63 131.23,95.04 v2(130.92,95.35) ; v2(120.02,91.04) 120.15,90.91 120.15,90.8 120.29,90.67 UC1.AM55 ; UC1.AA65 v2(125.37,96.64) ; v2(120.7,64.41) 120.62,64.41 UC1.AM8 ; UC1.T2 128.61,60.78 v2(128.61,61.07) 128.39,61.28 UC1.T4 128.83,61.98 128.83,62.06 ; UC1.G66 132.59,97.4 v2(132.93,97.74) ; v2(114.18,42.44) 114.4,42.67 UX1.16 ; v2(109.32,37.15) 109.82,37.65 110.59,37.65 110.9,37.96 UX1.32 ; UC1.V18 UC1.V17 ; UC1.V18 126.91,69.67 126.08,70.32 UC1.Y19 126.01,70.32 v2(125.64,70.7) ; UC1.AT35 v2(117.99,80.08) UC1.AR35 UC1.AP35 ; v2(168.69,52.94) 168.29,53.34 PUH01.8 ; 132.84,78.34 132.76,78.25 UC1.J32 ; 132.84,78.34 133.17,78.67 UC1.F33 133.42,79 v2(133.41,79.15) 133.41,79.39 UC1.F35 ; 132.84,78.34 133.17,78 UC1.F32 ; UC1.L18 130.22,69.67 v2(129.89,69.34) 130.21,69.02 UC1.L17 UC1.L16 ; UC1.U10 127.11,64.92 v2(126.82,65.22) ; UC1.F35 v2(132.84,80.08) UC1.J35 ; UC1.E18 134.13,69.87 UC1.D18 134.74,69.69 v2(135,69.69) 135.38,69.69 UC1.B18 ; UC1.AW18 UC1.BA18 ; UC1.B62 v2(135.04,94.65) UC1.D62 ; UC1.J8 131.22,63.78 v2(131.06,63.62) UC1.L8 ; v2(121.7,63.38) 121.7,63.39 121.7,63.44 121.51,63.62 UC1.AK8 ; 115.64,77.42 115.6,77.42 ; 115.64,77.42 v2(115.62,77.44) 115.6,77.42 ; UC1.E15 133.49,67.4 v2(133.49,67.35) 133.17,67.03 UC1.F13 ; UC1.AR11 118.14,65.72 v2(118.14,65.46) 118.52,65.46 UC1.AP10 ; v2(160.5,80.15) 160.62,80.03 PUI01.14 ; UC1.AP35 v2(119.31,80.08) ; v2(119.31,80.08) UC1.AN37 v2(119.31,81) UC1.AN38 v2(119.31,81.89) UC1.AP38 ; UC1.AM61 120.81,94.78 121.02,94.78 UC1.AK63 121.3,94.97 122.12,94.97 UC1.AH63 122.51,95.36 v2(122.64,95.36) 122.33,95.67 UC1.AH64 ; UC1.G55 132.52,90.65 v2(132.84,90.97) ; UC1.AT56 117.67,91.45 v2(117.94,91.06) 117.99,91.01 117.99,90.98 118.34,90.63 UC1.AR55 118.03,90.3 v2(118.03,90.15) 118.03,89.98 UC1.AR53 117.97,89.32 v2(117.97,89.22) 117.97,89.13 UC1.AR52 118.33,88.68 118.07,88.41 v2(118.07,88.28) 118.07,88.12 UC1.AR50 118.02,87.55 v2(118.02,87.38) 118.02,87.25 118.33,86.94 UC1.AR48 118.33,86.94 118.01,86.61 v2(118.01,86.48) 118.01,86.36 UC1.AR46 118.05,85.74 v2(118.05,85.5) 118.05,85.43 UC1.AR45 118.34,85.04 118.08,84.76 v2(118.09,84.61) 118.09,84.48 118.33,84.23 UC1.AR43 118.33,84.09 118.59,83.83 v2(118.67,83.83) ; UC1.AW45 116.19,85.27 116.24,85.32 116.24,85.62 116.19,85.66 UC1.AW47 116.19,86.44 116.24,86.48 116.24,86.79 116.19,86.83 UC1.AW49 ; UC1.AW45 116.19,84.42 116.24,84.37 116.24,84 116.19,83.96 UC1.AW43 ; UC1.AW45 v2(115.69,84.86) UC1.BA45 ; v2(143.16,129.08) 143.02,129.22 PUG01.14 ; 128.83,62.06 UC1.R6 128.24,62.64 v2(128.1,62.64) ; 128.83,62.06 129.37,62.06 UC1.N6 ; v2(110.64,88.95) 110.64,88.08 111.58,87.14 113.56,87.14 113.63,87.2 114.83,87.2 UC1.BA49 ; v2(140.1,131.87) 140.21,131.98 PUG01.4 ; UC1.AL32 v2(121.4,77.34) ; UC1.L11 130.57,65.62 130.87,65.92 130.87,65.91 131.22,65.91 UC1.J11 131.22,66.21 v2(131.06,66.37) 131.06,66.37 131.22,66.54 UC1.J13 ; UC1.G58 v2(132.83,92.86) UC1.G60 132.52,93.45 v2(132.9,93.83) ; v2(121.67,72.09) 121.45,72.31 UC1.AK22 121.19,72.28 121.19,71.76 UC1.AK21 ; 134.21,90.03 134.08,89.77 UC1.E53 ; 134.21,90.03 v2(134.2,90.03) ; 134.21,90.03 134.21,90.03 134.21,90.04 UC1.D53 UC1.B53 ; UC1.B66 UC1.D66 134.49,97.13 134.17,96.82 v2(134.17,96.79) 134.17,96.59 133.89,96.3 UC1.E65 ; RC146.2 140.57,93.09 142.83,93.09 v2(142.96,93.21) ; UC1.AW53 UC1.BA53 ; UC1.AW53 116.34,89.52 116.34,89.15 116.24,89.04 116.24,88.5 UC1.AW51 ; UC1.AL28 121.52,75.51 v2(121.7,75.33) ; UC1.U64 v2(127.2,95.34) UC1.U63 ; UC1.AM13 120.39,66.82 120.66,67.09 120.66,68.06 v2(120.51,68.2) 120.68,68.37 UC1.AK16 121.05,68.5 120.68,68.87 120.68,68.88 120.53,69.02 v2(120.53,69.12) 121.05,69.63 UC1.AK18 ; UC1.G6 132.36,63.01 132.36,62.41 UC1.G5 v2(132.16,61.84) ; UC1.L4 131.12,61.46 v2(131.12,61.06) 131.12,60.65 UC1.L2 ; UC1.AR15 117.97,68.1 v2(117.97,68.2) 117.97,68.29 UC1.AR16 118.02,68.96 v2(118.02,69.02) ; UC1.V17 UC1.Y17 ; v2(125.91,66.33) 126.43,66.85 UC1.W13 ; UC1.AW41 115.7,82.38 v2(115.57,82.24) 115.43,82.38 UC1.BA41 ; UC1.BA32 115.6,77.42 ; UC1.A5 136.98,61.43 v2(136.98,60.94) ; UC1.BA66 UC1.AY66 v2(116.1,97.48) UC1.AW66 116.26,96.93 116.26,95.97 UC1.AW64 116.24,95.86 116.24,95.09 116.19,95.04 UC1.AW62 v2(115.66,94.62) UC1.BA62 ; v2(121.7,81) UC1.AL38 ; UC1.N68 v2(129.03,97.94) ; UC1.D34 v2(135.06,79.79) UC1.B34 ; v2(115.5,92.15) UC1.BA57 ; UC1.E21 134.11,71.69 v2(134.11,71.85) 134.11,71.87 134.55,72.31 UC1.D22 UC1.B22 ; v2(111.16,44.25) 110.9,44 UX1.9 ; v2(116.7,81.91) UC1.AU38 ; UC1.E6 133.55,63.44 133.55,63.55 v2(133.53,63.55) 133.17,63.91 UC1.F8 ; UC1.AM21 119.83,70.94 v2(119.32,70.94) ; UC1.AF15 123.44,67.72 v2(123.11,68.05) 123.04,68.05 UC1.AG16 ; UC1.AR58 v2(117.97,92.89) UC1.AT58 ; UC1.AN30 v2(119.31,77.34) UC1.AN32 ; v2(121.7,79.17) UC1.AL35 ; UC1.F4 133.6,61.44 v2(133.6,61.06) 133.6,60.67 UC1.F2 UC1.F1 133.7,58.85 134.83,57.72 136.09,57.72 138.71,55.1 140.11,55.1 140.57,54.65 141.8,54.65 142.71,53.74 CC17.2 143.58,53.74 v2(143.96,53.36) 143.96,52.41 144.27,52.1 147.37,52.1 147.62,52.36 147.62,56.12 147.37,56.37 144.23,56.37 143.98,56.12 v2(143.98,55.33) 143.79,55.33 143.62,55.49 143.47,55.49 CC18.2 143.44,56.09 142.93,56.6 140.27,56.6 139.78,56.12 139.12,56.12 136.19,59.05 v2(135.58,59.05) ; UC1.N65 v2(129.03,96.64) ; UC1.BA23 UC1.AW23 116.19,72.9 116.27,72.98 116.27,73.25 116.19,73.33 UC1.AW26 ; UC1.N13 129.39,66.87 v2(129.11,66.59) 128.82,66.87 UC1.R13 ; UC1.AM43 120.3,84.2 UC1.AL45 UC1.AM45 120.29,85.15 v2(119.88,85.55) 120.29,85.95 UC1.AM46 v2(119.89,86.48) ; UC1.B44 v2(135.06,84.74) UC1.D44 ; v2(119.32,70.02) 118.98,69.69 UC1.AP18 ; v2(132.82,89.15) 132.82,89.06 UC1.G52 ; v2(118.67,83.83) 118.33,83.5 UC1.AR42 UC1.AT42 ; UC1.U70 v2(127.2,99.24) ; UC1.E71 134.13,100.69 v2(134.22,100.78) ; UC1.AJ4 121.1,61.57 v2(120.72,61.95) 120.44,61.67 UC1.AL4 120.15,61.26 120.15,60.86 UC1.AL2 ; 135.94,78.65 136.94,78.65 137.55,78.04 139.43,78.04 139.78,77.68 CC7.2 ; PRB35.2 v2(198.47,44.89) ; v2(123.73,66.59) 124.09,66.87 UC1.AD13 ; UC1.AF10 122.75,64.92 v2(122.72,64.96) ; UC1.AB16 v2(125.62,68.06) 125.25,67.79 UC1.AB15 ; UC1.N10 129.73,64.92 v2(130.13,65.32) ; UC1.J25 132.12,74.54 v2(132.83,74.54) 133.18,75.02 UC1.F27 133.7,74.53 134.17,74.53 v2(134.2,74.5) UC1.D25 ; UC1.D6 v2(135.08,62.63) 135.08,62.02 UC1.C5 ; UC1.U66 v2(127.2,96.64) ; v2(114.18,39.4) 114.45,39.67 UX1.23 ; UC1.BA36 v2(115.55,79.9) UC1.AW36 ; UC1.AA68 v2(125.37,97.94) ; UC1.AT2 117.79,60.86 v2(118,61.08) 118,61.33 UC1.AT4 117.79,61.71 UC1.AR5 118.33,62.54 v2(118.16,62.71) ; UC1.AG18 123.05,69.34 123.24,69.34 UC1.AF17 123.88,68.7 v2(123.99,68.7) 124.32,68.37 UC1.AD16 124.83,68.8 124.83,69.26 UC1.AB18 125.05,69.67 UC1.AD19 UC1.AD20 124.44,71.01 124.44,71.58 UC1.AD21 UC1.AB21 125.4,71.77 125.92,71.77 UC1.Y21 126.47,71.22 v2(126.5,71.22) 126.25,70.97 UC1.Y20 ; UC1.AP70 v2(118.9,98.52) UC1.AP68 118.52,97.95 118.46,97.88 118.18,97.88 118.11,97.95 UC1.AT68 ; RC56.2 126.06,56.08 125.68,56.47 125.68,57.44 v2(125.81,57.57) ; UC1.AW30 116.19,75.78 116.24,75.74 116.24,75.33 116.19,75.28 UC1.AW28 v2(115.7,74.92) UC1.BA28 ; v2(117.38,68.2) 117.03,67.85 UC1.AU15 ; UC1.AK69 121.4,98.93 v2(121.61,98.72) 121.4,98.51 UC1.AK68 ; UC1.U69 v2(127.2,98.59) ; v2(117.97,64.56) 118.33,64.2 UC1.AR8 ; UC1.N21 129.47,71.62 v2(129.79,71.3) 130.12,70.97 UC1.L20 ; UC1.H15 v2(132.14,68.2) 131.28,68.2 UC1.K16 131.11,68.5 131.48,68.87 131.48,69.25 131.11,69.62 UC1.K18 131.27,69.67 131.27,69.67 131.77,69.67 UC1.H18 ; UC1.AD8 124.3,63.68 124.46,63.84 124.85,63.84 v2(124.85,63.84) 124.86,63.84 124.97,63.84 125.19,63.62 UC1.AB8 ; UC1.U67 v2(127.2,97.29) ; UC1.P19 128.66,70.32 128.97,70.01 v2(129.06,70.01) 129.38,70.32 UC1.N19 ; UC1.D10 135,64.92 v2(135.1,65.02) 135.2,64.92 UC1.B10
  BOTTOM w0.279: JDIMM1.30 71.9,104.99 v2(72.75,104.14)
  BOTTOM w0.305: JDIMM1.60 69.57,97.49 69.22,97.85 69.22,98.12 v2(69.24,98.15) 69.58,98.49 JDIMM1.56 ; v2(69.74,58.15) 69.9,57.99 JDIMM1.210 ; JDIMM1.184 70.07,64.49 v2(69.7,64.86) ; v2(81.1,54.31) 81.1,53.05 80.78,52.74 JDIMM1.231 ; JDIMM2.252 61.1,47.49 v2(62.3,48.7) ; JDIMM1.176 72.2,66.49 72.52,66.81 73.26,66.81 73.59,66.48 v2(73.59,66.18) ; JEDP1.13 213.19,54.45 213.8,53.84 v2(213.84,53.84) ; v2(56.96,63.49) 56.96,63.49 JDIMM2.188 ; JDIMM1.82 69.53,91.99 69.05,92.47 69.05,92.79 v2(69.12,92.86) ; v2(69.66,101.81) 69.98,101.49 JDIMM1.44 ; JDIMM1.103 80.53,86.74 80.83,87.04 v2(80.83,87.11) 80.96,86.98 80.96,86.3 80.4,85.74 JDIMM1.107 ; JDIMM2.196 56.96,61.49 v2(56.96,61.49) ; JDIMM1.86 69.91,90.99 v2(69.52,90.6) ; v2(69.65,106.7) 69.94,106.99 JDIMM1.22 ; JDIMM1.218 70.01,55.99 v2(69.53,56.46) 69.52,56.45 69.52,55.23 69.76,54.99 JDIMM1.222 ; v2(56.96,99.49) 56.96,99.49 JDIMM2.52 ; JDIMM1.14 69.79,108.99 69.2,109.58 v2(69.2,109.9) 69.28,109.99 JDIMM1.10 ; JDIMM2.6 56.96,110.99 v2(56.96,110.99) ; JDIMM2.168 56.98,68.49 v2(56.9,68.57) ; JFP1.4 219.5,31.22 v2(219.92,31.64) 220,31.57 JFP1.3 ; JDIMM2.85 67.67,91.24 v2(67.72,91.29) ; JDIMM1.81 80.32,92.24 80.63,92.54 v2(80.63,92.73) ; v2(81.33,92.76) 81.33,92.93 81.02,93.24 JDIMM1.77 ; JDIMM1.78 73.22,92.99 v2(73.27,92.94) ; JDIMM2.248 56.96,48.49 v2(56.96,48.49) ; JDIMM1.89 80.17,90.24 v2(80.44,90.5) ; JDIMM1.185 81.07,64.24 v2(81.3,64) 80.54,63.24 JDIMM1.189 ; JEDP1.35 v2(213.33,43.45) ; v2(77.89,129.7) 78.04,129.55 JWLAN1.33 ; JDIMM2.73 67.32,94.24 v2(67.66,94.58) ; v2(67.63,112.73) 67.13,112.24 JDIMM2.1 ; JDIMM2.217 67.55,56.24 v2(67.77,56.46) ; JDIMM2.230 v2(56.96,52.99) ; JDIMM1.234 69.92,51.99 v2(69.5,52.4) 69.5,51.15 69.67,50.99 JDIMM1.238 ; JDIMM2.206 v2(56.96,58.99) ; JDIMM1.205 80.39,59.24 v2(80.5,59.12) ; v2(64.59,60.91) 65.26,60.24 JDIMM2.201 ; JDIMM2.56 56.96,98.49 v2(56.96,98.49) ; JEDP1.20 v2(211.36,50.95) ; v2(73.06,88.65) 73.06,87.79 72.58,87.32 72.58,86.36 72.22,85.99 JDIMM1.106 ; JWLAN1.57 v2(77.82,135.55) ; v2(56.9,85.59) 57.3,85.99 JDIMM2.106 ; JSSD1.27 32.87,32.82 33.11,32.58 34.03,32.58 v2(34.27,32.82) 34.37,32.93 JSSD1.21 ; JHDD1.4 188.7,34.91 v2(188.82,34.79) ; JESPI1.9 107.07,29.5 107.62,28.96 v2(107.62,28.2) ; JDIMM1.6 70.12,110.99 v2(69.73,110.61) ; v2(67.68,98.18) 67.62,98.24 JDIMM2.57 ; JFP1.1 221,31.71 v2(221.18,31.89) ; JDIMM2.218 v2(56.96,55.99) ; JDIMM1.72 73.41,94.49 v2(73.94,95.02) 73.43,95.53 72.45,95.53 72.41,95.49 JDIMM1.68 ; PUI01.4 163.18,77.25 163.23,77.3 163.33,77.3 163.49,77.45 v2(163.58,77.45) ; JDIMM2.214 v2(56.96,56.99) ; JSSD1.45 28.37,35.06 v2(28.26,35.17) ; JDIMM1.213 80.07,57.24 v2(80.37,56.94) ; v2(80.85,48.46) 80.94,48.55 80.94,49.33 80.53,49.74 JDIMM1.243 ; JWLAN1.75 v2(77.8,140.05) ; v2(69.48,53.8) 69.68,53.99 JDIMM1.226 ; JSSD1.71 21.87,35.04 v2(21.29,35.62) ; JDIMM2.10 56.96,109.99 v2(56.96,109.99) ; v2(81.19,60.93) 81.19,61.57 80.51,62.24 JDIMM1.193 ; v2(67.68,53.8) 67.68,53.79 67.63,53.74 JDIMM2.227 ; JEDP1.38 212.92,41.95 213.2,42.22 v2(213.32,42.22) ; v2(56.96,111.99) 56.96,111.99 JDIMM2.2 ; JDIMM2.35 67.7,103.74 68.28,103.16 v2(68.28,102.5) ; JDIMM1.188 70.12,63.49 v2(69.62,63) ; JWLAN1.69 v2(77.82,138.55) ; JDIMM2.192 56.96,62.49 v2(56.96,62.49) ; JDIMM1.64 69.51,96.49 v2(69.17,96.83) ; v2(80.93,95.97) 80.93,94.46 80.71,94.24 JDIMM1.73 ; JDIMM2.202 v2(56.96,59.99) ; v2(80.33,89.01) 80.1,89.24 JDIMM1.93 ; JDIMM2.94 56.96,88.99 v2(56.96,88.99) ; JDIMM2.226 v2(56.96,53.99) ; JDIMM1.47 80.14,100.74 v2(80.54,101.14) ; JDIMM2.27 67.71,105.74 68.01,105.43 v2(68.01,105.38) ; v2(70.31,125.66) 70.45,125.8 JWLAN1.18 ; JSSD1.3 38.87,35.01 v2(39.11,35.25) 39.37,34.98 JSSD1.1 ; JWLAN1.63 v2(77.8,137.05) ; v2(25.05,35.12) 25.37,34.8 JSSD1.57 ; v2(69.65,67.72) 69.88,67.49 JDIMM1.172 ; JDIMM1.61 80.51,97.24 v2(80.61,97.14) ; v2(190.66,34.79) 190.2,35.25 JHDD1.1 ; JDIMM2.222 v2(56.96,54.99) ; v2(56.96,65.49) 56.96,65.49 JDIMM2.180 ; JDIMM2.82 58.25,91.99 v2(56.96,91.99) ; JSSD1.15 35.87,33.22 v2(36.16,32.94) ; JDIMM2.19 67.86,107.74 68.3,107.3 v2(68.3,106.92) 68.12,106.74 JDIMM2.23 ; v2(56.99,90.36) 57.36,89.99 JDIMM2.90 ; JDIMM2.14 56.96,108.99 v2(56.96,108.99) ; JWLAN1.7 80.03,123.05 v2(80.17,122.91) 80.17,121.8 79.92,121.55 JWLAN1.1 ; v2(80.43,54.31) 80,54.74 JDIMM1.223 ; v2(56.96,92.99) 56.96,92.99 JDIMM2.78 ; v2(56.96,49.49) 56.96,49.49 JDIMM2.244 ; JDIMM2.210 v2(56.96,57.99) ; JSSD1.75 20.87,34.6 v2(20.49,34.98) ; v2(37.63,32.94) 37.37,33.19 JSSD1.9 ; JSSD1.73 21.37,34.82 v2(20.54,35.66) ; v2(67.81,59.03) 67.81,59.12 67.7,59.24 JDIMM2.205 ; JDIMM2.40 58.25,102.49 v2(56.96,102.49) ; JDIMM2.39 67.42,102.74 v2(67.66,102.5) ; v2(80.55,66.21) 80.55,66.58 80.4,66.74 JDIMM1.175 ; v2(56.96,100.49) 58.25,100.49 JDIMM2.48 ; v2(213.25,49.61) 213.1,49.45 JEDP1.23 ; v2(60.05,87.56) 59.62,87.99 JDIMM2.98 ; JDIMM2.176 56.96,66.49 v2(56.96,66.49) ; JDIMM1.248 v2(69.62,48.49) ; JDIMM2.72 56.96,94.49 v2(56.96,94.49) ; JDIMM1.239 80.22,50.74 v2(80.68,51.2) 80.14,51.74 JDIMM1.235 ; JDIMM2.15 67.68,108.74 v2(67.8,108.85) ; v2(80.47,60.93) 80.16,61.24 JDIMM1.197 ; JEDP1.32 v2(213.33,44.95) ; JWLAN1.26 v2(70.27,127.8) ; v2(30.09,32.6) 31.16,32.6 31.37,32.82 JSSD1.33 ; PUI02.4 v2(162.34,99.54) ; JWLAN1.51 v2(77.81,134.05) ; v2(69.35,58.61) 69.73,58.99 JDIMM1.206 ; v2(56.96,104.99) 56.96,104.99 JDIMM2.30 ; v2(30.09,35.14) 29.87,34.93 JSSD1.39 ; JWLAN1.39 v2(80.24,131.05) ; v2(187.2,34.79) JHDD1.7 ; JEDP1.17 v2(211.45,52.45) ; JDIMM2.234 v2(56.96,51.99) ; JSSD1.51 v2(26.87,32.88) ; JDIMM2.238 v2(56.96,50.99) ; JWLAN1.45 v2(80.24,132.55)
  BOTTOM w0.356: CC71.2 CC70.2 110.21,66.67 109.8,66.27 v2(109,66.27) ; CC7.2 142.43,76.62 142.82,76.23 v2(145.07,76.23) 146.45,76.23 146.69,76.47 146.69,77.68 146.68,77.91 v2(146.68,78.79) 146.68,80.6 146.39,80.89 142.93,80.89 142.43,80.39 CC6.2 142.15,79.71 142.05,79.81 139.35,79.81
  BOTTOM w0.381: RC198.2 114.56,104.58 115.2,103.94 115.67,103.94 v2(115.8,104.08) ; CC88.2 108.71,61.83 109.03,62.14 CC69.2 ; v2(118.53,44.19) 118.91,44.19 119.07,44.35 UC4.3 ; v2(140.26,102.79) 140.26,102.81 140.32,102.87 RC144.2 CC15.2 ; JESPI1.11 112.07,28.01 v2(112.48,28.42) ; RC131.1 RC132.1 141.46,101.68 141.16,101.99 140.57,101.99 140.38,102.18 v2(140.32,102.18) ; U2.5 106.98,125.78 v2(106.51,126.25) ; v2(160.63,81.45) 160.3,81.12 PHZ04.2 ; EU2601.3 v2(17.81,53.67) ; v2(106.22,28.2) 105.57,27.56 JESPI1.12 ; PCH10.2 168.69,50.89 v2(168.69,50.33) ; RC147.2 v2(142.94,90.99) ; PRH04.2 v2(166.79,50.33)
  BOTTOM w0.457: v2(159.29,116.75) 159.05,116.51 PCZ02.2 ; CX5.2 117.83,39.71 118.29,40.17 v2(118.29,40.48) ; PCM19.2 99.63,132.52 v2(100.11,132.04) 99.64,131.57 PCM18.2 ; v2(119.45,47.52) 118.51,47.52 RC109.2 ; CC88.2 108.45,61.76 107.94,61.26 v2(107.94,61.15) ; v2(166.86,48.1) 166.8,48.16 PR1802.2 ; Q25.4 v2(29.59,122.71) ; DA6.1 v2(210.22,44.39) ; Q25.1 v2(27.53,121.41) ; v2(120.92,46.7) CC3.2
  BOTTOM w0.508: JFP.7 v2(220.26,27.3) ; JHDD1.13 192,34.65 v2(191.8,34.85) ; CM5.2 145.8,35.85 145.8,35.88 146.05,36.13 v2(146.05,36.44) ; JIOB1.5 v2(209.2,35.48) ; CU7.2 v2(19.59,55.3) ; CU12.2 v2(20.67,39.17) ; PCB27.2 v2(194.28,48.26) ; CX3.2 109.06,42.4 v2(109.06,42.03) ; JIOB1.17 214.68,35.1 v2(213.98,35.1) ; v2(23.88,61.02) 23.82,60.96 CU10.2 ; v2(113.01,137.14) 112.67,137.48 PC308.2 ; v2(217.6,62.15) JEDP1.42 ; PCB12.2 205.3,54.35 v2(205.75,53.91) ; JIOB1.10 204.21,36.81 v2(204.21,37.89) ; v2(76.52,120.45) JWLAN1.77 ; v2(91.17,31.94) 90.56,31.34 JKBBL1.6 ; v2(148.52,64.6) 148.16,64.6 147.65,64.09 CC79.2 CC67.2 ; PCB26.2 205.89,47.94 PRB24.2 204.96,47.04 v2(205.46,46.54) ; JIOB1.1 v2(213.2,35.8) ; PRM11.2 v2(100.11,128.9) ; EU2701.1 221.14,34.86 v2(221.55,35.26) ; CL18.2 23.94,83.96 v2(24.48,84.5) ; v2(178.37,66.68) 178.93,66.12 C30.2 ; v2(147.86,38.11) 147.75,38.01 RM12.1 ; JODD1.7 v2(188.2,65.59) ; CL6.2 25.69,84.59 v2(25.6,84.5) ; v2(198.01,39.61) UU3.2 ; v2(146.54,72.14) 145.95,72.14 145.35,71.54 CC84.2 ; CS24.2 46.8,31.81 47.02,32.04 v2(47.02,32.52) ; v2(128.69,41.02) 129.16,41.5 UC3.4 ; v2(117.11,45.19) 116.81,44.89 CC2.1 ; PCG10.2 v2(138.56,130.55) ; JODD1.26 184.28,65.8 v2(184.46,65.62) ; v2(4.16,133.54) 3.68,133.05 LED1.1 LED1.3 ; v2(154.66,60.15) 154.26,60.15 PCA106.2 ; PRH02.2 v2(172.18,53.46) ; JIOB1.8 v2(206.2,37.89) ; JFP1.9 v2(217.51,27.3) ; v2(206.8,50.36) PCB25.2 ; RM13.1 CM8.1 v2(151.7,37.62) ; CU14.2 v2(15.08,40.57) ; v2(128.05,29.46) JTP1.10 ; v2(185.94,69.02) 185.2,68.28 JODD1.2 ; PC1801.2 v2(168.31,45.38) ; CS8.2 v2(179.61,42.03) ; v2(147.54,35.62) 147.83,35.33 CM6.2 147.82,34.91 CM2.2 ; JDIMM2.262 49.18,46.23 v2(49.18,47.6) ; v2(147.1,108.94) 147.35,109.19 PCZ23.2 ; v2(199.7,65.24) 199.14,65.8 JODD1.25 ; PR308.2 v2(113.67,140.28) ; CU15.2 v2(15.97,43.85) ; v2(120.76,29.46) 121.05,29.75 JTP1.5 ; JKB1.31 58.27,31.15 v2(57.58,31.85) ; JODD1.14 v2(191.2,65.69) JODD1.13 ; v2(111.67,36.03) 112.16,36.52 RX5.2 ; v2(112.68,54.78) 112.45,55 RC145.2 ; v2(19.27,1.44) 18.71,2 JSPK1.6 ; JIOB1.2 v2(212.2,35.8) ; v2(218.8,33.03) 218.87,32.96 C37.2 ; CL12.2 v2(24.72,60.82) ; v2(109.19,70.42) 109.32,70.29 RC87.2 ; PHZ05.2 v2(138.53,134.62) ; PR1805.2 167.55,49.08 167.98,48.64 v2(168.16,48.64) ; PRB39.2 201.81,45.22 202.21,44.83 v2(202.73,44.83) ; PBATT1.12 v2(151.85,33.34) ; PCA118.2 PCA117.2 153.34,68.4 v2(152.56,67.62) ; CU8.2 v2(17.78,59.96) ; UU1.2 v2(20.99,43.62) ; JFP1.10 v2(223.15,28.72) ; v2(126.66,32.05) 126.44,32.27 C27.2 ; C21.2 100.7,124.31 100.36,124.65 v2(100.36,124.84) ; PRB37.2 204.36,45.59 PCB30.2 v2(204.38,44.83) ; EU2602.1 v2(23.15,49.86) ; v2(122.34,32.06) 122.53,32.25 123.14,32.25 C26.2 ; v2(107.65,37.15) CX1.2 CX2.2 RX8.2 ; v2(85.91,35.96) 86.51,36.56 RC164.2 ; v2(154.66,61.4) 154.26,61.4 PCA108.2 ; JEDP1.41 214.48,39.25 v2(213.97,38.74) ; v2(111.46,143.75) PR508.2 PC516.2 ; CC5.2 92.11,37.17 91.7,37.57 v2(91.7,37.72) ; JIOB1.18 v2(195.38,32.29) ; JDIMM2.261 v2(47.07,112.66) ; PC2504.2 49.47,27.85 v2(49.3,27.68) ; PCA107.2 154.26,62.67 v2(154.66,62.67) ; PC15.2 95.86,143.57 v2(96.05,143.38) ; PC313.2 v2(113.85,129.75) ; PC2503.2 55.56,25.83 v2(55.53,25.8) ; PC12.2 v2(174.02,41.27) ; v2(89.32,47.89) 89.71,48.28 JCMOS1.2 ; RI16.2 19.29,105.35 v2(18.97,105.04) ; v2(201.46,40.51) 201.28,40.69 CU16.2 ; PC11.2 175.93,41.52 v2(175.68,41.27) ; JWLAN1.76 v2(80.11,141.15) ; JSSD1.77 v2(40.47,35.05) ; RC110.2 v2(94.45,39.37) ; PCM16.2 96.36,128.5 v2(95.87,128.01) 95.47,128.41 PCM15.2 ; JSSD1.76 v2(19.77,34.99) ; JODD1.1 185.2,65.31 v2(185.12,65.39) ; v2(115.05,25.51) JTP1.9 ; JDIMM1.261 87.05,43.02 v2(86.64,42.6) 85.62,41.59 85.62,38.78 CC4.2 86.11,38.11 86.75,37.47 88.35,37.47 QC2.3 ; v2(165.9,78.08) 165.89,78.09 PCI10.2 165.13,78.19 PCI11.2 ; PBATT1.11 177,34.72 v2(177.26,34.98) ; CU5.2 23.61,43.52 v2(23.05,43.52) ; JSPK1.5 v2(13.25,2) ; v2(182.9,30.09) JHDD1.14 ; JFAN1.6 177.01,70.44 v2(178.76,72.19) ; v2(203.87,42.98) 203.62,42.73 EU4012.1 ; PR303.2 v2(110.78,143.39) ; CM1.2 145.18,38.24 145.64,37.78 v2(146.02,37.78) ; CX4.2 v2(109.44,45.38) ; JFAN1.5 179.71,74.4 v2(179.15,73.85) ; v2(181.09,71.69) 181.16,71.61 181.21,71.61 JFAN1.4 ; JKB1.32 v2(84.43,31.8) ; v2(163.8,139.2) 163.75,139.15 PR511.2 ; CU6.2 v2(18.58,55.3) ; CU11.2 v2(15.66,39.17) ; JODD1.8 v2(188.2,68.43) ; PCI31.2 163.8,99.66 PCI30.2 v2(164.65,99.6) ; v2(220.44,65.39) 221.2,64.63 JPWR1.1 ; PC1805.2 v2(164.04,50.08) ; RC7.2 140.06,68.69 v2(140.02,68.73) ; v2(178.02,34.98) v4(178.02,35.59) US2.2 ; JPWR1.5 218.6,65.62 v2(218.32,65.34) ; RC133.1 v2(137.68,104.94) ; DA4.1 17.05,19.06 v2(17.05,20.32) ; JKBBL1.5 97.25,29.58 v2(97.39,29.44) ; PCB16.2 PCB17.2 v2(193.96,50.36) ; PCB22.2 v2(175.04,41.27) ; EU2603.3 v2(19.41,37.16) ; JIOB1.9 v2(205.2,37.89) ; PJPDC1.7 v2(76.66,149.32) ; RC6.1 v2(130.29,39.94) ; JPWR1.6 v2(226.8,65.39) ; CU9.2 v2(21.66,59.96) ; C41.2 v2(9.79,122.74) ; CU13.2 v2(20.57,41.82)
  vias: v2(0.43,121.36) v2(0.43,116.03) v2(0.45,126.47) v2(1.21,81.78) v2(2.7,118.8) v2(2.96,123.88) v2(3.42,88.67) v2(4.87,66.52) v2(4.97,62.29) v2(5.5,108.26) v2(6.89,106.23) v2(7.02,121.34) v2(7.02,117.53) v2(7.15,125.15) v2(8.23,63.3) v2(8.42,21.01) v2(8.54,108.26) v2(8.83,81.78) v2(9.94,133.66) v2(10.05,105.03) v2(10.58,106.23) v2(10.83,60.33) v2(10.83,21.01) v2(10.89,63.37) v2(10.96,89.82) v2(11,0.56) v2(11.65,86.86) v2(11.65,84.51) v2(12.1,39.05) v2(12.23,43.24) v2(14.28,43.57) v2(14.26,38.9) v2(16.65,130.67) v2(18.62,0.43) v2(18.98,102.65) v2(18.96,100.87) v2(18.96,99.02) v2(18.96,97.16) v2(18.98,95.36) v2(21.64,101.04) v2(22.26,45.84) v2(22.51,81.53) v2(22.9,53.46) v2(23.36,86.73) v2(23.36,85.61) v2(23.36,84.5) v2(23.66,81.59) v2(23.97,80.45) v2(24.27,130.67) v2(24.48,86.73) v2(24.48,85.61) v2(24.66,53.46) v2(24.8,77.15) v2(24.8,76.51) v2(24.8,33.65) v2(24.99,31.87) v2(25.03,28.71) v2(25.03,28.13) v2(25.05,30.82) v2(25.05,30.23) v2(25.37,80.89) v2(25.45,54.61) v2(25.6,86.73) v2(25.6,85.61) v2(25.81,39.17) v2(25.88,82.61) v2(26.09,41.97) v2(26.2,80.89) v2(26.24,0.43) v2(26.77,75.12) v2(27.15,83.05) v2(27.81,15.22) v2(27.81,13.25) v2(27.81,11.28) v2(27.97,75.12) v2(28.05,87) v2(28.16,65.73) v2(28.16,63.94) v2(28.55,82.04) v2(29.63,66.68) v2(29.59,66.07) v2(29.78,15.22) v2(29.78,13.25) v2(29.78,11.28) v2(30.07,42.6) v2(30.39,89.42) v2(30.39,87.63) v2(30.74,42.6) v2(30.88,85.4) v2(31.27,133.67) v2(31.28,86.57) v2(31.4,42.6) v2(31.76,67.08) v2(31.75,15.22) v2(31.75,13.25) v2(31.75,11.28) v2(33.56,15.81) v2(33.86,0.43) v2(34.27,12.44) v2(35.59,72.6) v2(35.59,71.4) v2(37.12,9.62) v2(37.37,14.28) v2(38.89,133.67) v2(40.77,20.84) v2(40.77,13.22) v2(40.77,5.73) v2(41.75,42.6) v2(44.79,60.19) v2(45.45,136.48) v2(49.38,22.93) v2(50.77,38.03) v2(51.22,37.65) v2(52.04,141.37) v2(54.9,31.87) v2(54.9,25.83) v2(55.53,31.87) v2(56.9,86.99) v2(56.9,83.68) v2(56.9,69.21) v2(56.96,107.99) v2(56.96,106.99) v2(56.96,105.99) v2(56.96,103.49) v2(56.96,101.49) v2(56.96,97.49) v2(56.96,96.49) v2(56.96,95.49) v2(56.96,90.99) v2(57,22.93) v2(59.66,141.37) v2(60.05,104.37) v2(60.05,92.89) v2(60.05,77.37) v2(60.05,67.34) v2(60.02,60.94) v2(60.02,49.99) v2(60.68,109.81) v2(60.81,111.17) v2(60.81,103.07) v2(60.81,99.92) v2(60.81,98.61) v2(60.81,97.08) v2(60.81,94.03) v2(60.81,90.93) v2(60.81,87.56) v2(60.81,85.26) v2(60.81,80.93) v2(60.81,76.13) v2(60.81,74.49) v2(60.81,72.93) v2(60.81,71.87) v2(60.81,69.7) v2(60.81,68.57) v2(60.81,66.01) v2(60.78,64.22) v2(60.78,62.64) v2(60.78,59.32) v2(60.78,57.5) v2(60.78,55.45) v2(60.78,53.93) v2(60.78,51.77) v2(60.78,48.7) v2(60.85,108.58) v2(60.91,105.91) v2(60.86,82.9) v2(60.86,78.82) v2(61.45,109.81) v2(61.54,55.45) v2(61.57,98.61) v2(61.63,87.56) v2(61.57,76.13) v2(61.57,74.49) v2(61.57,67.34) v2(61.57,66.01) v2(62.34,111.17) v2(62.34,104.37) v2(62.34,103.07) v2(62.34,99.92) v2(62.34,98.61) v2(62.34,97.08) v2(62.34,94.03) v2(62.34,92.89) v2(62.34,90.93) v2(62.34,85.26) v2(62.34,80.93) v2(62.34,77.37) v2(62.34,76.13) v2(62.34,74.49) v2(62.34,72.93) v2(62.34,71.87) v2(62.34,69.7) v2(62.34,68.57) v2(62.34,67.34) v2(62.34,66.01) v2(62.3,64.22) v2(62.3,62.64) v2(62.3,60.91) v2(62.3,59.32) v2(62.3,57.5) v2(62.3,55.45) v2(62.3,53.93) v2(62.3,51.77) v2(62.3,49.99) v2(62.37,108.58) v2(62.43,105.91) v2(62.38,82.9) v2(62.38,78.82) v2(63.1,104.37) v2(63.1,92.89) v2(63.1,76.13) v2(63.1,68.57) v2(63.07,60.91) v2(63.15,87.56) v2(63.73,109.81) v2(63.83,64.22) v2(63.83,62.64) v2(63.83,60.91) v2(63.83,59.32) v2(63.83,57.5) v2(63.83,53.93) v2(63.83,51.77) v2(63.83,49.99) v2(63.83,48.7) v2(63.86,111.17) v2(63.9,108.58) v2(63.86,104.37) v2(63.86,99.92) v2(63.86,97.08) v2(63.86,94.03) v2(63.86,90.93) v2(63.86,85.26) v2(63.91,82.9) v2(63.86,80.93) v2(63.91,78.82) v2(63.86,76.13) v2(63.86,74.49) v2(63.86,72.93) v2(63.86,71.87) v2(63.86,69.7) v2(63.86,68.57) v2(63.86,67.34) v2(63.96,105.91) v2(64.55,89.05) v2(64.62,98.61) v2(64.62,92.89) v2(64.62,87.56) v2(64.63,77.51) v2(64.62,66.01) v2(64.59,55.45) v2(64.62,22.93) v2(64.99,46.91) v2(67.28,141.37) v2(67.73,100.35) v2(67.73,95.88) v2(67.72,92.86) v2(67.68,88.14) v2(67.74,62.64) v2(67.71,52.4) v2(67.75,86.23) v2(67.77,67.72) v2(67.79,65.99) v2(67.79,64.86) v2(67.81,49.27) v2(68.8,35.28) v2(69.47,99.62) v2(69.65,46.94) v2(69.78,60.73) v2(71.38,147.79) v2(71.67,75.72) v2(72.24,22.93) v2(72.42,146.36) v2(72.42,145.6) v2(72.42,144.84) v2(72.42,144.08) v2(72.66,77.98) v2(72.93,50.3) v2(72.96,80.79) v2(72.96,60.89) v2(73.06,146.36) v2(73.06,145.6) v2(73.06,144.84) v2(73.06,144.08) v2(73.12,82.26) v2(73.43,79.3) v2(73.44,76.63) v2(73.38,57.72) v2(73.39,54.31) v2(73.51,110.77) v2(73.54,108.45) v2(73.51,105.39) v2(73.53,83.52) v2(73.47,73.21) v2(73.51,71.86) v2(73.48,69.65) v2(73.52,64.45) v2(73.53,62.76) v2(73.48,59.44) v2(73.51,51.99) v2(73.62,100.54) v2(73.55,75.05) v2(73.58,67.87) v2(73.58,48.49) v2(73.73,70.83) v2(73.92,97.49) v2(73.88,84.62) v2(74.17,91.48) v2(74.23,55.99) v2(74.27,109.76) v2(74.25,99.14) v2(74.35,66.18) v2(74.38,87.11) v2(74.48,80.79) v2(74.64,82.26) v2(74.76,89.52) v2(74.91,57.72) v2(74.91,54.31) v2(75.04,110.77) v2(75.04,109.76) v2(75.04,105.39) v2(75.04,104.14) v2(74.95,79.3) v2(74.95,77.98) v2(74.96,76.63) v2(74.99,73.21) v2(75.04,71.86) v2(75.04,64.45) v2(75.01,59.44) v2(75,55.99) v2(75.04,51.99) v2(74.96,50.3) v2(75.06,108.45) v2(75.15,100.54) v2(75.05,83.52) v2(75.08,75.05) v2(75.1,67.87) v2(75.11,66.18) v2(75.05,62.76) v2(75.1,48.49) v2(75.24,60.89) v2(75.25,70.83) v2(75.45,97.49) v2(75.47,95.02) v2(75.55,92.94) v2(75.69,91.48) v2(75.68,84.62) v2(75.73,50.3) v2(75.9,87.11) v2(76.01,80.79) v2(76.17,82.26) v2(76.32,89.52) v2(76.43,57.72) v2(76.44,54.31) v2(76.54,99.14) v2(76.48,79.3) v2(76.49,76.63) v2(76.54,73.24) v2(76.52,69.65) v2(76.53,59.44) v2(76.49,50.3) v2(76.56,110.77) v2(76.59,108.45) v2(76.56,105.39) v2(76.56,104.14) v2(76.57,83.52) v2(76.6,75.05) v2(76.56,71.86) v2(76.63,67.87) v2(76.57,64.45) v2(76.58,62.76) v2(76.56,51.99) v2(76.56,48.49) v2(76.67,100.54) v2(76.78,70.83) v2(76.97,97.49) v2(76.99,95.02) v2(77.22,91.48) v2(77.32,109.76) v2(77.32,104.14) v2(77.43,87.11) v2(77.4,66.18) v2(77.39,55.99) v2(77.82,89.52) v2(78.28,44.75) v2(79.79,150.47) v2(79.86,22.93) v2(80.07,35.28) v2(80.33,95.96) v2(80.39,110.73) v2(80.38,108.18) v2(80.41,104.21) v2(80.71,114.04) v2(80.9,126.3) v2(80.98,110.73) v2(80.96,108.24) v2(80.96,89.01) v2(80.97,76.03) v2(81.13,101.14) v2(81.59,89.01) v2(81.64,48.46) v2(82.01,92.76) v2(82.08,83.05) v2(82.5,48.46) v2(82.64,126.3) v2(82.65,92.76) v2(82.76,95.97) v2(82.77,83.05) v2(82.77,35.28) v2(83.13,48.46) v2(83.22,131.95) v2(83.22,131.31) v2(83.22,130.68) v2(83.22,130.04) v2(83.28,92.76) v2(83.8,89.09) v2(85.76,137.09) v2(86.14,150.47) v2(87.48,22.93) v2(88.43,131.95) v2(88.43,131.31) v2(89.52,132.6) v2(91.35,138.04) v2(91.35,137.41) v2(91.35,136.77) v2(91.98,138.04) v2(91.98,137.41) v2(91.98,136.77) v2(91.98,136.14) v2(92.3,133.69) v2(92.62,138.04) v2(92.62,137.41) v2(92.74,133.28) v2(93.06,149.03) v2(93.06,46.29) v2(93.25,150.45) v2(94.47,132.77) v2(94.65,53.84) v2(95.09,133.4) v2(95.09,132.15) v2(95.1,22.93) v2(95.28,125.6) v2(95.67,138.04) v2(95.67,137.41) v2(95.72,132.77) v2(95.88,125.6) v2(96.49,125.6) v2(96.55,138.04) v2(96.55,137.41) v2(97.07,125.57) v2(97.25,50.54) v2(99.98,135.95) v2(99.98,135.31) v2(101.44,143.57) v2(102.33,143.57) v2(102.66,23.88) v2(103.22,143.57) v2(104.17,142.69) v2(104.24,62.16) v2(104.62,62.67) v2(104.94,142.69) v2(105.6,79.46) v2(105.84,75.75) v2(106.02,144.01) v2(106.51,88.96) v2(106.47,83.36) v2(106.97,144.01) v2(106.97,143.38) v2(107.05,81.07) v2(107.11,75.74) v2(107.16,95.72) v2(107.31,149.37) v2(107.26,93.76) v2(107.5,90.63) v2(107.46,79.48) v2(107.73,143.38) v2(107.73,142.74) v2(107.67,73.98) v2(107.76,85.34) v2(107.93,139.39) v2(107.93,72.03) v2(108.05,136.96) v2(108.11,142.24) v2(108.12,91.97) v2(108.35,97.27) v2(108.29,88.96) v2(108.43,143.38) v2(108.43,142.74) v2(108.49,93.78) v2(108.47,77.52) v2(108.8,81.08) v2(108.89,99.59) v2(108.92,95.72) v2(108.87,83.63) v2(108.9,75.74) v2(109.32,91.97) v2(109.27,90.66) v2(109.37,79.46) v2(109.52,85.3) v2(109.52,73.98) v2(109.78,72.06) v2(110.16,99.02) v2(110.28,97.29) v2(110.28,23.88) v2(110.41,77.54) v2(110.64,81.02) v2(110.73,75.7) v2(111.13,42.44) v2(111.13,40.92) v2(111.13,39.4) v2(111.28,73.98) v2(111.51,79.49) v2(111.88,83.66) v2(112.54,135.89) v2(112.65,42.44) v2(112.65,40.92) v2(112.65,39.4) v2(113.13,135.89) v2(113.84,100.26) v2(114.52,135.76) v2(114.93,149.37) v2(115.29,135.76) v2(115.5,102.56) v2(116.3,135.76) v2(116.94,102.67) v2(117.06,135.76) v2(117.38,70.92) v2(117.83,135.95) v2(117.9,23.88) v2(117.99,95.62) v2(117.99,81) v2(118.01,70.95) v2(118.06,103.52) v2(118.12,102.29) v2(118.59,135.95) v2(118.68,95.62) v2(118.67,70.95) v2(118.82,108.7) v2(118.82,107.43) v2(118.82,106.16) v2(119.31,95.57) v2(119.91,96.55) v2(120.6,106.77) v2(120.6,104.86) v2(120.6,102.96) v2(121.48,84.67) v2(122.31,68.11) v2(122.55,149.37) v2(122.56,106.13) v2(122.56,104.23) v2(123.83,103.98) v2(123.83,102.07) v2(125.52,23.88) v2(126.06,107.73) v2(126.56,91.18) v2(126.56,89.28) v2(126.97,135.49) v2(127.57,91.18) v2(127.57,89.28) v2(128.15,82) v2(130.17,149.37) v2(130.92,96.65) v2(130.92,96) v2(133.14,23.88) v2(134.27,130.87) v2(134.27,130.23) v2(135.16,130.87) v2(135.16,130.23) v2(136.05,130.87) v2(136.05,130.23) v2(137.61,86.33) v2(137.79,149.37) v2(139.61,119.69) v2(140.12,120.2) v2(140.5,119.69) v2(141,120.2) v2(141.13,34.82) v2(141.39,119.69) v2(141.39,119.06) v2(141.94,85.02) v2(142.02,86.42) v2(142.09,131.18) v2(142.24,88.02) v2(142.46,36.08) v2(142.92,38.3) v2(143.23,134.16) v2(143.23,132.86) v2(143.23,131.56) v2(143.54,87.94) v2(143.99,38.41) v2(144.09,134.71) v2(144.05,117.2) v2(144.05,113.98) v2(144.05,113.28) v2(144.12,34.41) v2(144.45,130.71) v2(144.58,60.1) v2(144.58,59.51) v2(144.59,58.91) v2(144.69,137.22) v2(144.69,135.95) v2(144.79,134.16) v2(144.79,132.86) v2(144.79,131.56) v2(144.94,137.85) v2(145,136.58) v2(144.99,135.39) v2(145.32,137.22) v2(145.32,135.95) v2(145.41,149.37) v2(145.45,100.01) v2(145.45,99.37) v2(145.58,137.85) v2(145.64,136.58) v2(145.64,135.31) v2(145.7,134.68) v2(145.96,137.22) v2(145.96,135.95) v2(145.96,85.91) v2(146.21,137.85) v2(146.27,136.58) v2(146.27,135.31) v2(146.34,134.68) v2(146.59,137.22) v2(146.59,135.95) v2(146.59,86.04) v2(146.85,137.85) v2(146.91,136.58) v2(146.91,135.31) v2(146.97,134.68) v2(146.97,103.37) v2(147.23,137.22) v2(147.23,135.95) v2(147.48,137.85) v2(147.54,136.58) v2(147.61,103.37) v2(147.74,86.04) v2(148.14,67.92) v2(148.15,66.76) v2(148.38,23.88) v2(148.79,117.12) v2(148.79,115.1) v2(148.79,113.08) v2(148.88,86.04) v2(150.78,132.9) v2(150.81,117.12) v2(150.81,115.1) v2(150.81,113.08) v2(151.42,132.9) v2(152.24,132.08) v2(152.24,131.44) v2(152.24,130.81) v2(152.24,130.17) v2(152.83,117.12) v2(152.83,115.1) v2(152.83,113.08) v2(153.03,149.37) v2(153.4,59.35) v2(153.4,58.72) v2(154.21,126.17) v2(154.21,125.41) v2(154.21,124.39) v2(154.21,123.63) v2(154.22,52.19) v2(154.67,59.35) v2(154.67,58.72) v2(154.8,52.19) v2(154.97,142.43) v2(154.97,141.66) v2(154.97,140.9) v2(154.96,48.58) v2(154.96,44.97) v2(155.42,51.56) v2(155.55,48.58) v2(155.55,44.97) v2(155.6,74.48) v2(155.74,142.43) v2(155.74,141.66) v2(155.74,140.9) v2(155.74,95.05) v2(155.74,94.04) v2(155.86,96.2) v2(155.86,75.05) v2(156,23.88) v2(156.12,93.53) v2(156.24,96.88) v2(156.16,95.58) v2(156.16,94.57) v2(156.18,74.48) v2(156.5,143.19) v2(156.5,142.43) v2(156.5,141.66) v2(156.5,140.9) v2(156.47,96.16) v2(156.47,95.08) v2(156.47,94.06) v2(156.5,75.05) v2(156.47,73.91) v2(156.79,95.58) v2(156.79,94.57) v2(156.75,93.53) v2(156.75,92.9) v2(156.82,74.48) v2(156.75,73.39) v2(156.88,96.88) v2(157.11,96.09) v2(157.11,95.08) v2(157.11,94.06) v2(157.13,75.04) v2(157.07,73.91) v2(157.26,143.19) v2(157.26,142.43) v2(157.26,141.66) v2(157.26,140.9) v2(157.26,91.24) v2(157.26,90.61) v2(157.43,95.58) v2(157.43,94.57) v2(157.39,93.53) v2(157.39,92.9) v2(157.39,73.33) v2(157.45,74.46) v2(157.66,99.96) v2(157.66,98.67) v2(157.66,97.37) v2(157.74,96.09) v2(157.74,95.08) v2(157.74,94.06) v2(157.7,73.84) v2(157.7,72.83) v2(158,100.81) v2(158.02,93.53) v2(158.02,92.9) v2(158.02,88.32) v2(158.02,73.33) v2(158.02,72.32) v2(158.06,95.58) v2(158.06,94.57) v2(158.15,91.94) v2(158.09,74.46) v2(158.24,137.85) v2(158.34,73.84) v2(158.34,72.83) v2(158.4,135.44) v2(158.36,96.82) v2(158.38,96.09) v2(158.38,95.08) v2(158.38,94.06) v2(158.7,95.58) v2(158.7,94.57) v2(158.66,93.53) v2(158.66,92.9) v2(158.66,88.32) v2(158.66,73.33) v2(158.66,72.32) v2(158.78,91.94) v2(158.85,77.68) v2(158.85,75.08) v2(159.04,135.19) v2(158.97,73.84) v2(158.97,72.83) v2(159.22,99.96) v2(159.22,98.67) v2(159.22,97.37) v2(159.2,78.53) v2(159.29,73.33) v2(159.29,72.32) v2(159.56,74.53) v2(159.61,73.84) v2(159.61,72.83) v2(159.93,73.33) v2(159.93,72.32) v2(160.24,73.84) v2(160.24,72.83) v2(160.36,100.34) v2(160.41,77.68) v2(160.41,76.38) v2(160.41,75.08) v2(160.63,74.44) v2(160.56,73.33) v2(160.56,72.32) v2(160.65,149.37) v2(161.56,78.05) v2(162.21,90.91) v2(162.21,90.28) v2(162.21,89.64) v2(162.21,89.01) v2(162.21,88.37) v2(162.47,125.79) v2(162.47,125.03) v2(162.47,124.07) v2(162.47,123.31) v2(162.47,122.36) v2(162.47,121.6) v2(162.51,95.55) v2(162.51,94.94) v2(162.53,93.79) v2(162.53,93.16) v2(163.17,65.72) v2(163.17,65.08) v2(163.23,63.94) v2(163.61,136.39) v2(163.61,135.76) v2(163.61,135.12) v2(163.61,134.49) v2(163.58,59.77) v2(163.62,23.88) v2(163.8,65.72) v2(163.8,65.08) v2(164.18,73.23) v2(164.37,60) v2(164.82,73.23) v2(164.78,60.46) v2(165.16,60) v2(165.4,60.56) v2(165.69,48.1) v2(165.69,46.09) v2(165.77,60) v2(165.9,73.23) v2(166.04,60.56) v2(166.28,47.1) v2(166.35,60) v2(166.53,73.23) v2(166.67,60.56) v2(166.94,60) v2(166.86,46.09) v2(167.31,60.56) v2(167.53,59.99) v2(167.99,57.02) v2(167.99,56.38) v2(168.18,37.89) v2(168.27,149.37) v2(168.63,57.02) v2(168.63,56.38) v2(168.88,38.59) v2(168.88,37.89) v2(169.07,141.79) v2(169.26,57.02) v2(169.26,56.38) v2(169.49,134.18) v2(169.58,38.59) v2(169.58,37.89) v2(169.71,60.81) v2(169.71,59.8) v2(169.9,57.02) v2(169.9,56.38) v2(169.98,126.57) v2(170.28,38.59) v2(170.28,37.89) v2(170.46,118.97) v2(170.66,57.02) v2(170.98,38.59) v2(170.98,37.89) v2(171.24,23.88) v2(171.29,57.02) v2(171.43,103.76) v2(171.91,96.16) v2(172.6,88.57) v2(172.75,50.22) v2(172.75,49.53) v2(172.75,48.45) v2(172.75,47.75) v2(175.42,81.49) v2(177.01,41.84) v2(177.64,41.84) v2(178.86,23.88) v2(180.55,75.85) v2(182.12,29.12) v2(184.57,50.35) v2(185.56,39.41) v2(186.14,39.41) v2(186.65,71.29) v2(186.72,39.41) v2(189.44,68.33) v2(189.39,48) v2(189.74,29.28) v2(190.03,68.33) v2(190.03,48) v2(190.41,47.11) v2(190.41,46.48) v2(191.04,47.11) v2(191.04,46.48) v2(191.68,47.11) v2(191.68,46.48) v2(192.57,48.38) v2(193.26,53.91) v2(193.26,53.27) v2(193.33,50.41) v2(193.33,49.78) v2(193.26,48.38) v2(193.9,68.95) v2(197.36,29.28) v2(199.29,51.75) v2(199.29,49.57) v2(200.38,50.66) v2(201.43,67.74) v2(201.47,51.75) v2(201.47,49.57) v2(204.76,38.54) v2(204.98,29.28) v2(205.39,38.54) v2(208.57,53.12) v2(208.57,51.36) v2(208.57,49.52) v2(212.6,29.28) v2(213.6,23.9) v2(213.9,36.97) v2(214.08,33.13) v2(215.96,32.03) v2(216.55,68.91) v2(219.93,37.52) v2(221.22,23.88) v2(224.17,68.97) v2(224.99,47.72) v2(224.97,40.1) v2(224.97,32.48) v2(224.97,24.86) v2(227.97,62.36) v2(227.96,54.74) v4(8.16,122.87) v4(13.19,107.5) v4(22.59,51.32) v4(24.14,36.81) v4(30.97,40.17) v4(40.72,41.08) v4(50.33,37.52) v4(63.99,34.78) v4(83.14,109.1) v4(87.13,34.45) v4(90.1,58.61) v4(92.79,136.58) v4(96.25,123.68) v4(102.37,103.49) v4(102.8,142.88) v4(115.91,135.06) v4(144.61,85.58) v4(148.04,134.98) v4(156.42,98.69) v4(157.08,72.6) v4(157.84,142.04) v4(161.91,72.47) v4(163.15,66.3) v4(166.25,45.6) v4(192.46,47.13) v4(192.59,53.86) v4(204.5,39.4)
