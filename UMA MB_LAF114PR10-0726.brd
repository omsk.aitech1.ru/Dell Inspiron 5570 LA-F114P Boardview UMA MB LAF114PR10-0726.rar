# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
THM_SML1_DATA: length 9.3
  BOTTOM w0.102: v1(109.23,124.19) 108.94,124.48 U2.7 107.06,124.48 106.88,124.3 106.68,124.3 105.48,125.5 105.48,127.99 106,128.5 Q11.1 107.38,128.5 R48.2
TON_1.2V: length 5.1
  BOTTOM w0.102: v1(94.34,127.19) 94.34,127.57 94.01,127.9 94.01,129.17 93.57,129.61 PRM07.2
  BOTTOM w0.203: PRM07.2 93.56,130.03 94.01,130.49 94.4,130.49 94.69,130.79 PUM01.9
TOUCH_PAD_INTR#: length 18.7
  TOP w0.102: v2(112.78,59.74) 112.78,58.8 v1(109.3,55.32) 109.3,54.74 107.58,53.02 107.58,50.88 RC114.2 105.65,48.18 DZ3.2
  BOTTOM w0.076: v2(112.78,59.74) 112.78,59.74 112.78,61.11 113.46,61.8 114,61.8 114.39,62.19 UC1.BA5
TOUCH_PANEL_PD#: length 8.5
  BOTTOM w0.076: UC1.AY5 115.01,62.24 114.78,62.48 113.83,62.48 113.6,62.24 112.89,62.24
  BOTTOM w0.102: 112.89,62.24 110.85,60.21 110.85,59.08 109.99,58.21 109.67,58.21 RC118.2
TOUCH_SCREEN_PD#: length 144.2
  TOP w0.102: R19.2 214.66,42.92 D5.2 v2(214.66,44.57)
  IN1 w0.127: v2(104.48,39.39) 105.08,38.79 112.18,38.79 114.37,36.6 127.2,36.6 127.48,36.32 130.06,36.32 134.7,40.95 151.1,40.95 154.78,37.28 158.19,37.28 161.47,33.99 179.59,33.99 180.48,34.88 183.19,34.88 183.84,35.53 192.29,35.53 193.29,36.53 201.35,36.53 205.37,40.55 209.5,40.55 212.81,43.87 213.96,43.87 v2(214.66,44.57)
  BOTTOM w0.102: RC118.1 RC115.2 108.71,56.71 108.43,56.43 108.43,55.43 108.81,55.05 108.81,52.71 107.85,51.75 107.85,49.41 106.82,48.38 106.31,48.38 104.46,46.53 104.46,43.49 104.18,43.21 v1(104.18,39.91) 104.18,39.69 v2(104.48,39.39)
TP_EN: length 3.3
  TOP w0.102: R19.1 C16.1 v2(213.39,41.62) v1(212.87,41.62)
  BOTTOM w0.102: JEDP1.39 213.22,41.45 v2(213.39,41.62)
TP_EN#: length 81.6
  TOP w0.102: v2(96.08,31.41) 96.08,29.49 v1(96.56,29.01) 97.06,28.51 97.06,26.66 R38.1 ; v2(41.71,60.2) 41.6,60.3 UE1.49
  IN1 w0.127: v2(96.08,31.41) 95.91,31.25 92.75,31.25 92.22,30.72 85.58,30.72 85.17,30.31 66.08,30.31 65.03,31.36 62.93,31.36 60.15,34.13 56.14,34.13 45.36,44.91 45.36,51.25 41.28,55.34 41.28,59.77 v2(41.71,60.2)
TP_LOCK#: length 7.6
  TOP w0.102: v1(126.81,31.15) 125.1,31.15 v2(123.43,29.47) 123.43,28.74 R41.2 124.82,28.5 D6.2
  BOTTOM w0.102: v2(123.43,29.47) 123.05,29.85 JTP1.3
TP_WAKE_KBC#: length 131.2
  TOP w0.102: v2(106.65,43.87) 107.29,44.5 107.29,47.02 106.93,47.38 105.35,47.38 104.92,47.81 DZ3.1 ; v2(103.92,43.62) 103.5,43.2 103.5,38.51 v1(109.03,32.97) 110.09,31.91 110.09,28.12 v2(110.13,28.09) 109.3,28.09 Q9.1 ; RE14.1 33.59,59.71 v2(34.29,60.41) 34.67,60.41 35.2,60.95 UE1.33
  IN1 w0.127: v2(103.92,43.62) 106.4,43.62 v2(106.65,43.87) ; v2(34.29,60.41) 33.99,60.11 33.99,58.3 39.66,52.63 39.66,41.84 44.71,36.79 49.38,36.79 53.85,32.33 57.93,32.33 61.18,29.08 64.44,29.08 65.34,28.18 93.43,28.18 94.73,29.47 95.78,29.47 96.28,28.96 99.3,28.96 100.67,30.33 108.46,30.33 110.13,28.67 v2(110.13,28.09)
TPM_ID: length 24.6
  TOP w0.102: v2(149.73,59.38) 149.7,59.38 148.2,57.88 RC64.1 148.2,56.69 RC63.2 147.75,56.22 147.75,54.76 v1(147.91,54.61)
  IN1 w0.127: v2(149.73,59.38) 149.61,59.38 149.38,59.6 145.86,59.6 143.94,61.53 141.53,61.53 139.35,63.7 v2(139.35,64.57)
  BOTTOM w0.076: UC1.D8 134.92,64.4 135.1,64.58 135.87,64.58 136.04,64.64 136.31,64.64 136.41,64.67 136.91,64.67 137.74,63.84 138.62,63.84 139,64.23
  BOTTOM w0.102: 139,64.23 v2(139.35,64.57)
TPM_SPI_IRQ#: length 40.5
  IN2 w0.127: v2(121.7,54.1) 120.12,54.1 118.03,52.01 118.03,47.31 116.49,45.78 116.49,44.89 117.04,44.34 117.04,42.75 116.48,42.19 v2(116.16,42.19)
  BOTTOM w0.102: v2(116.16,42.19) 115.73,42.19 115.71,42.17 UX1.18 ; UC1.M2 130.05,59.91 130.05,58.89 130.74,58.2 131.91,58.2 131.98,58.27 132.76,58.27 134.05,56.99 RX4.2 134.56,55.86 134.56,54.76 132.23,52.44 128.17,52.44 v1(127.94,52.2) 127.59,51.86 125.53,51.86 124.85,52.54 123.86,52.54 123.54,52.86 123.01,52.86 121.77,54.1 v2(121.7,54.1)
TSENSE_1PH_CPU: length 4.3
  TOP w0.102: PRZ63.1 v1(146.58,115.82)
  TOP w0.254: v2(146.4,116.95) 145.84,116.95 PCZ36.1 145.59,115.83 PRZ63.1
  BOTTOM w0.203: v2(146.4,116.95) 146.53,117.07 147.16,117.07 147.33,116.9 PUZ01.23
TSENSE_1PH_CPU_R: length 53
  TOP w0.254: PRZ63.2 PRZ65.1 v2(144.05,114.9)
  IN2 w0.254: v2(144.05,114.9) 144.69,115.54 144.69,116.14 147.23,118.68 151.93,118.68 153.2,119.95 153.96,119.95 155.1,121.09 155.1,121.98 152.82,124.26 152.82,137.47 148.88,141.41 140.31,141.41 v2(138.53,139.63)
  BOTTOM w0.254: PHZ05.1 v2(138.53,139.63)
TSENSE_2PH_CPU: length 4.5
  TOP w0.102: v1(147.4,110.42) 148.26,110.42 v2(148.69,110.85)
  TOP w0.254: v2(148.69,110.85) 149.13,111.29 PCZ22.1 148.27,111.47 PRZ34.2
  BOTTOM w0.203: v2(148.69,110.85) 148.69,111.17 149.01,111.49 PUZ01.11
TSENSE_2PH_CPU_R: length 44.7
  TOP w0.102: v1(146.34,111.97) 146.74,112.37 PRZ36.1
  TOP w0.254: v2(148.09,110.85) 147.79,110.85 147.34,111.3 PRZ34.1 PRZ36.1
  IN1 w0.254: v2(161.26,81.45) 162.04,81.45 163.01,82.42 163.01,95.72 161.76,96.98 161.76,101.48 159.67,103.56 158.53,103.56 154.09,108.01 154.09,109.66 153.76,109.99 152.3,109.99 150.95,111.33 148.35,111.33 148.09,111.08 v2(148.09,110.85)
  BOTTOM w0.254: v2(161.26,81.45) 161.21,81.4 161.21,80.75 PHZ04.1
TX_P80DATA: length 2.9
  TOP w0.102: v2(70.33,130.8) RW6.2 v1(69.29,131.5)
  BOTTOM w0.102: v2(70.33,130.8) JWLAN1.38
UART1_CTS#: length 4.3
  BOTTOM w0.076: TP79.1 124.59,57.71 124.59,59.62 124.72,59.92 124.72,60.99 125.08,61.35 UC1.AB4
UART_P80: length 5.1
  TOP w0.102: v2(72.62,131.89) v1(72.24,131.5) RW10.2
  BOTTOM w0.102: JWLAN1.32 72.24,129.3 72.62,129.68 v2(72.62,131.89)
UG_1.2V: length 7.8
  TOP w0.102: v2(89.44,141.47) v1(88.92,141.47)
  IN2 w0.762: 90.81,141.35 92.3,141.35 94.46,139.19 94.46,136.46
  vias: v2(90.08,141.47) v2(94.52,135.71) v2(94.52,135.12)
UG_VCCSA: length 5.9
  TOP w0.102: v2(168.63,62.06) v1(168.63,62.57)
  IN2 w0.762: v2(164.08,64.02) 166.67,64.02 v2(168.63,62.06)
UGATE_CHG:
  vias: v2(197.34,52.26)
USB2_ID: length 4.4
  BOTTOM w0.076: v1(122.26,57.73) 121.92,58.07 121.92,59.05 122.07,59.21 122.07,59.53 122.23,59.82 122.23,60.02 122.15,60.14 122.15,60.32 122.36,60.67 UC1.AG3
  BOTTOM w0.102: RC67.1 122.26,56.85 v1(122.26,57.73)
USB2_VBUSSENSE: length 5.2
  BOTTOM w0.076: 121.87,59.42 121.87,59.51 122.05,59.85 122.05,59.98 121.97,60.11 121.97,60.35 122.1,60.61 122.1,61.08 UC1.AG4
  BOTTOM w0.102: RC68.1 121.86,57.25 121.86,57.79 121.74,57.91 121.74,59.29 121.87,59.42
USB3_CRX_DTX_N1: length 151.7
  IN2 w0.122: v2(24.07,53.46) 23.82,53.21 23.82,47.11 27.63,43.3 48.52,43.3 55.09,36.72 91.31,36.72 91.98,37.39 95.78,37.39 96.05,37.66 98.06,37.66 98.33,37.39 105.69,37.39 106.2,37.9 109.68,37.9 110.08,37.5 113.7,37.5 114.64,36.56 117.63,36.56 117.94,36.88 123.76,36.88 124.26,37.38 129.28,37.38 131.92,40.03 131.92,51.81 134.75,54.64 134.75,60.49 133.53,61.71 132.9,61.71 132.33,62.28 132.33,62.98 132.54,63.19 132.54,63.3 132.26,63.59 v2(132.11,63.59)
  BOTTOM w0.076: UC1.H8 132.14,64.08 132.29,63.93 132.29,63.68 132.2,63.59 v2(132.11,63.59)
  BOTTOM w0.097: v2(24.07,53.46) 23.98,53.37 23.98,52.96 23.61,52.6 LU3.2 22.02,52.43 RU6.2
USB3_CRX_DTX_N1_C: length 9.3
  BOTTOM w0.097: RU6.1 21.1,52.43 LU3.1 20.73,52.6 20.58,52.75 19.85,52.75 19.77,52.67 EU2601.9 EU2601.1 18.16,52.67 18,52.83 17.74,52.83 17.61,52.7 v3(17.61,52.33) 17.61,52.05 16.33,50.78 15.63,50.78 14.9,50.04 14.89,50.04 14.87,50.03 14.58,50.03 14.38,49.83 JUSB1.5
USB3_CRX_DTX_N3: length 151.7
  IN2 w0.122: v2(26.61,42.24) 26.86,41.98 27.07,41.98 27.25,42.15 48.7,42.15 54.91,35.95 83.7,35.95 84.11,35.54 88.69,35.54 89.2,36.04 91.59,36.04 92.26,36.71 96.25,36.71 96.52,36.98 97.7,36.98 97.97,36.71 112.78,36.71 113.61,35.89 118.35,35.89 118.66,36.2 119.47,36.2 121.05,36.2 124.04,36.2 124.54,36.71 129.56,36.71 132.6,39.74 132.6,51.53 135.89,54.83 135.89,58.78 136,58.88 136,59.45 135.92,59.52 135.92,62.84 134.43,64.33 133.87,64.33 133.56,64.02 132.17,64.02 v2(131.61,64.57)
  BOTTOM w0.076: v2(131.61,64.57) 131.61,64.88 131.49,65 UC1.J10
  BOTTOM w0.097: v2(26.61,42.24) 27.2,42.24 27.4,42.03 27.4,38.75 26.89,38.24 26.89,37.71 25.2,36.02 LU6.2 23.51,35.85 RU12.2
USB3_CRX_DTX_N3_C: length 17.4
  BOTTOM w0.097: RU12.1 22.59,35.85 LU6.1 22.11,36.02 21.9,36.23 21.42,36.23 21.35,36.16 EU2603.9 EU2603.1 19.71,36.16 19.55,36.31 19.41,36.31 18.96,35.86 18.96,31.28 v3(18.31,30.63) 17.92,30.23 17.92,29.14 17.95,29.1 17.95,28.52 17.92,28.48 17.92,28.27 16.56,26.91 15.63,26.91 14.88,26.16 14.48,26.16 14.38,26.06 JUSB2.5
USB3_CRX_DTX_P1: length 151.8
  IN2 w0.122: v2(132.85,63.59) 132.79,63.54 132.79,63.09 132.58,62.87 132.58,62.38 133,61.96 133.63,61.96 135,60.6 135,54.53 132.17,51.71 132.17,39.92 129.38,37.13 124.36,37.13 123.86,36.63 118.05,36.63 117.73,36.31 114.54,36.31 113.6,37.25 109.98,37.25 109.58,37.65 106.3,37.65 105.79,37.14 98.23,37.14 97.96,37.41 96.16,37.41 95.89,37.14 92.09,37.14 91.42,36.47 54.99,36.47 48.41,43.05 27.53,43.05 23.57,47.01 23.57,53.38 v2(23.49,53.46)
  BOTTOM w0.076: UC1.G8 132.52,63.91 v2(132.85,63.59)
  BOTTOM w0.097: v2(23.49,53.46) 23.79,53.16 23.79,53.04 23.54,52.78 23,52.78 22.69,53.1 LU3.3 22.02,53.26 RU5.2
USB3_CRX_DTX_P1_C: length 9.4
  BOTTOM w0.097: RU5.1 21.1,53.26 LU3.4 20.71,53.1 20.55,52.94 19.98,52.94 19.75,53.17 EU2601.8 EU2601.2 18.16,53.17 18,53.01 17.66,53.01 17.38,52.74 17.38,52.09 16.26,50.96 15.56,50.96 14.83,50.23 14.58,50.23 14.38,50.43 JUSB1.6
USB3_CRX_DTX_P3: length 151.7
  IN2 w0.122: v2(26.61,41.65) 26.69,41.73 27.18,41.73 27.35,41.91 48.6,41.91 54.81,35.7 83.6,35.7 84.01,35.29 88.8,35.29 89.3,35.8 91.7,35.8 92.37,36.47 96.36,36.47 96.62,36.73 97.6,36.73 97.87,36.47 112.68,36.47 113.51,35.64 118.45,35.64 118.77,35.95 119.47,35.95 121.05,35.95 124.14,35.95 124.64,36.46 129.66,36.46 132.85,39.64 132.85,51.43 136.14,54.72 136.14,58.68 136.25,58.78 136.25,59.55 136.17,59.63 136.17,62.94 134.54,64.57 133.77,64.57 133.45,64.26 132.27,64.26 132.13,64.4 132.13,64.47 v2(132.24,64.57)
  BOTTOM w0.076: UC1.H10 131.87,64.83 132.13,64.57 v2(132.24,64.57)
  BOTTOM w0.097: RU11.2 23.51,36.69 LU6.3 24.22,36.52 24.29,36.44 24.29,36.28 24.36,36.21 25.12,36.21 26.7,37.78 26.7,38.32 27.21,38.83 27.21,41.96 27.12,42.05 26.99,42.05 26.61,41.66 v2(26.61,41.65)
USB3_CRX_DTX_P3_C: length 17.4
  BOTTOM w0.097: RU11.1 22.59,36.69 LU6.4 22.01,36.52 21.91,36.42 21.57,36.42 21.33,36.66 EU2603.8 EU2603.2 19.71,36.66 19.55,36.5 19.33,36.5 18.77,35.94 18.77,31.35 18.41,30.99 18.35,30.99 17.94,30.58 17.94,30.53 17.73,30.31 v3(17.73,28.81) 17.73,28.34 16.48,27.1 15.55,27.1 14.8,26.34 14.48,26.34 14.38,26.44 JUSB2.6
USB3_CTX_DRX_N1: length 164.6
  IN2 w0.122: v2(136.76,66.28) 136.76,66.27 137.09,65.94 137.09,65.44 137.26,65.27 137.26,63.59 138.22,62.63 138.22,60 136.57,58.35 136.57,54.55 133.27,51.25 133.27,39.46 129.84,36.03 127.33,36.03 126.83,35.52 118.94,35.52 118.63,35.21 110.74,35.21 110.46,35.49 107.57,35.49 107.03,36.04 97.43,36.04 97.13,35.74 96.89,35.74 96.62,36.02 92.52,36.02 91.87,35.37 89.7,35.37 89.19,34.86 55.04,34.86 48.42,41.48 27.52,41.48 27.12,41.07 26.4,41.07 25.41,42.07 25.41,44.57 22.49,47.49 22.49,53.75 23.4,54.67 24.59,54.67 24.93,54.33 v2(24.93,54.33)
  BOTTOM w0.076: UC1.C13 135.19,66.77 135.02,66.77 134.91,66.66 134.91,66.52 135,66.43 135.04,66.43 135.16,66.31 135.31,66.31 135.57,66.58 135.57,66.87 135.61,66.91 135.84,66.99 135.98,66.99 136.17,66.93 136.32,66.93 136.42,66.98 136.58,66.98 136.58,66.97 137.01,66.97 137.16,66.82
  BOTTOM w0.097: v2(136.76,66.28) 137.16,66.68 137.16,66.82 ; CU2.1 24.18,54.3 24.48,54.61 24.67,54.61 24.93,54.35 v2(24.93,54.33)
USB3_CTX_DRX_N1_C: length 8.7
  BOTTOM w0.097: JUSB1.8 14.38,55.96 14.48,56.06 14.85,56.06 15.62,55.28 16.26,55.28 17.25,54.29 18.04,54.29 18.16,54.17 EU2601.4 EU2601.7 19.75,54.17 19.91,54.33 20.18,54.33 20.38,54.52 20.56,54.52 20.71,54.37 LU2.1 21.1,54.21 RU4.1
USB3_CTX_DRX_N1_R: length 1.6
  BOTTOM w0.097: RU4.2 22.02,54.21 LU2.2 22.39,54.37 22.55,54.53 22.91,54.53 CU2.2
USB3_CTX_DRX_N3: length 151.7
  IN2 w0.122: v2(26.77,39.62) 26.69,39.7 26.69,39.95 26.84,40.1 27.46,40.1 27.91,40.55 46.88,40.55 53.5,33.94 89.57,33.94 90.08,34.44 92.26,34.44 92.9,35.09 96.23,35.09 96.56,34.77 97.58,34.77 97.93,35.11 106.58,35.11 107.77,33.93 109.79,33.93 110.14,34.29 119.01,34.29 119.32,34.6 129.71,34.6 134.2,39.08 134.2,50.87 137.49,54.16 137.49,57.97 139.65,60.13 139.65,62.88 138.93,63.6 138.93,65.1 138.52,65.51 138.21,65.51 138.1,65.63 v2(138.09,65.63)
  BOTTOM w0.076: 138.5,67.35 138.39,67.46 138.39,67.47 138.04,67.82 137.35,67.82 137.26,67.72 136.53,67.72 136.44,67.82 136.4,67.82 136.14,68.07 UC1.B15
  BOTTOM w0.097: v2(26.77,39.62) 26.72,39.56 26.72,38.92 26.3,38.5 26.3,38.06 26.12,37.88 25.94,37.88 CU4.1 ; 138.5,67.35 138.59,67.26 138.59,65.73 138.44,65.57 138.15,65.57 v2(138.09,65.63)
USB3_CTX_DRX_N3_C: length 15
  BOTTOM w0.097: JUSB2.8 14.38,32.06 14.48,32.16 14.87,32.16 15.63,31.39 17.27,31.39 18.32,32.44 v3(18.32,36.28) 18.32,36.89 18.62,37.19 18.68,37.19 19.09,37.6 19.09,37.65 19.25,37.81 19.55,37.81 19.71,37.66 EU2603.4 EU2603.7 21.33,37.66 21.57,37.9 22.01,37.9 22.11,37.8 LU5.1 22.59,37.63 RU10.1
USB3_CTX_DRX_N3_R: length 1.6
  BOTTOM w0.097: CU4.2 24.4,37.95 24.06,37.95 23.9,37.8 LU5.2 23.51,37.63 RU10.2
USB3_CTX_DRX_P1: length 164.8
  IN2 w0.122: v2(137.34,66.28) 137.34,65.54 137.51,65.38 137.51,63.69 138.46,62.73 138.46,59.89 136.82,58.25 136.82,54.44 133.52,51.15 133.52,39.36 129.94,35.78 127.44,35.78 126.93,35.27 119.04,35.27 118.73,34.96 110.64,34.96 110.36,35.24 107.47,35.24 106.92,35.79 97.53,35.79 97.24,35.49 96.79,35.49 96.51,35.77 92.62,35.77 91.98,35.12 89.8,35.12 89.29,34.62 54.93,34.62 48.32,41.23 27.63,41.23 27.22,40.83 26.29,40.83 25.16,41.96 25.16,44.47 22.24,47.38 22.24,53.86 23.3,54.92 v2(24.93,54.92)
  BOTTOM w0.076: UC1.D13 134.87,66.88 135.09,67 135.09,67 135.23,67.08 135.58,67.08 135.81,67.15 136,67.15 136.12,67.12 136.31,67.12 136.38,67.14 136.65,67.14 136.65,67.14 137.08,67.14 137.22,67 137.23,67 137.33,66.9 137.33,66.84 137.34,66.83 137.34,66.82
  BOTTOM w0.097: 137.34,66.82 v2(137.34,66.28) ; CU1.1 24.45,54.8 24.81,54.8 v2(24.93,54.92)
USB3_CTX_DRX_P1_C: length 8.4
  BOTTOM w0.097: LU2.4 20.76,54.87 20.59,54.71 20.3,54.71 20.11,54.51 19.93,54.51 19.77,54.67 EU2601.6 EU2601.5 18.16,54.67 18,54.51 v3(17.56,54.51) 17.29,54.51 16.34,55.47 15.7,55.47 14.92,56.24 14.48,56.24 14.38,56.34 JUSB1.9
USB3_CTX_DRX_P1_R: length 1.6
  BOTTOM w0.097: RU3.2 22.02,55.04 LU2.3 22.42,54.87 22.57,54.72 22.91,54.72 CU1.2
USB3_CTX_DRX_P3: length 151.4
  IN2 w0.122: v2(26.19,39.62) 26.44,39.87 26.44,40.06 26.74,40.35 27.35,40.35 27.8,40.8 46.99,40.8 53.6,34.19 89.47,34.19 89.98,34.69 92.15,34.69 92.8,35.34 96.34,35.34 96.66,35.02 97.48,35.02 97.82,35.36 106.69,35.36 107.87,34.18 109.69,34.18 110.04,34.53 118.91,34.53 119.22,34.85 129.61,34.85 133.95,39.19 133.95,50.97 137.25,54.27 137.25,58.07 139.4,60.23 139.4,62.77 138.68,63.5 138.68,65 138.41,65.27 138.31,65.27 138.09,65.05 v2(138.09,65.05)
  BOTTOM w0.076: 138.57,67.53 138.11,67.98 137.28,67.98 137.19,67.89 136.6,67.89 136.55,67.95 UC1.A15
  BOTTOM w0.097: v2(26.19,39.62) 26.53,39.28 26.53,39 26.11,38.58 26.11,38.13 26.04,38.07 25.94,38.07 25.67,38.34 CU3.1 ; 138.57,67.53 138.58,67.53 138.78,67.34 138.78,65.65 138.52,65.39 138.38,65.39 138.09,65.1 v2(138.09,65.05)
USB3_CTX_DRX_P3_C: length 15
  BOTTOM w0.097: JUSB2.9 14.38,32.44 14.48,32.34 14.94,32.34 15.71,31.58 17.19,31.58 18.13,32.52 18.13,35.95 18.1,35.99 18.1,36.57 18.13,36.61 18.13,36.97 v3(18.72,37.56) 19.17,38 19.55,38 19.71,38.16 EU2603.5 EU2603.6 21.35,38.16 21.42,38.08 21.93,38.08 22.14,38.3 LU5.4 22.59,38.46 RU9.1
USB3_CTX_DRX_P3_R: length 1.6
  BOTTOM w0.097: CU3.2 24.4,38.14 24.04,38.14 23.88,38.3 LU5.3 23.51,38.46 RU9.2
USB20_VCC: length 2.8
  TOP w0.102: v2(199.81,39.25) v1(199.81,36.48)
USB30_VCCA: length 10.5
  TOP w2.032: 21.62,55.3 20.23,53.91 20.23,49.08 18.7,47.56 18.7,46.03
  vias: v2(18,44.64) v2(18,44) v2(18.64,44.64) v2(18.64,44) v2(22.26,57.4) v2(22.26,56.76) v2(22.89,57.4) v2(22.89,56.76) v4(23.2,56.17)
USB_CAMERA_EDP: length 4.1
  BOTTOM w0.097: JEDP1.34 211.47,43.95 210.87,44.55 210.87,44.83 210.23,45.47 210.23,45.94 210.1,46.08 L3.2 209.93,46.45 R18.1
USB_CAMERA_EDP#: length 4
  BOTTOM w0.097: R17.1 210.76,46.45 L3.3 210.6,46.08 210.42,45.9 210.42,45.6 v3(210.76,45.26) 211.06,44.97 211.06,44.63 211.54,44.14 211.71,44.14 211.76,44.19 211.76,44.37 211.84,44.45 JEDP1.33
USB_EN#: length 254
  TOP w0.102: RE17.1 31.87,71.35 32.39,70.83 UE1.13 34.42,70.83 34.76,70.5 v2(36.29,70.5)
  IN1 w0.127: v2(36.29,70.5) 37.69,69.1 37.69,56.75 43.84,50.61 43.84,43.01 54.26,32.58 59.54,32.58 62.29,29.83 64.4,29.83 65.55,28.68 91.98,28.68 93.27,29.98 96.67,29.98 97.68,30.98 118.18,30.98 118.78,30.39 135.55,30.39 136.75,31.59 143.48,31.59 146.45,28.61 156.55,28.61 158.23,30.28 161.38,30.28 161.95,29.72 180.38,29.72 182.06,31.4 199.41,31.4 v2(200.24,32.23)
  IN2 w0.127: v2(20.35,45.46) 20.37,45.48 20.37,53.78 22.64,56.05 26.98,56.05 34.2,63.26 34.2,68.42 36.27,70.5 v2(36.29,70.5)
  BOTTOM w0.102: UU1.4 22.01,44.57 21.12,45.46 v2(20.35,45.46) ; UU3.4 197.06,40.88 195.97,39.78 195.97,37.07 200.24,32.8 v2(200.24,32.23)
USB_OC0#: length 163.6
  IN2 w0.127: v2(29.13,38.78) 29.39,39.04 44.55,39.04 48.14,35.45 49.85,35.45 52.89,32.41 92.36,32.41 93.53,33.58 95.61,33.58 95.93,33.26 98.34,33.26 98.66,33.58 101.58,33.58 101.97,33.18 110.17,33.18 110.59,33.6 119.29,33.6 119.61,33.92 130,33.92 134.88,38.8 134.88,41.81 140.85,47.78 140.85,50.95 138.18,53.62 138.18,56.8 138.76,57.38 139.95,57.38 140.53,57.96 140.53,63.27 v2(139.99,63.81)
  BOTTOM w0.102: UU1.3 21.44,44.57 22.13,43.87 22.79,43.87 23.17,44.25 25.82,44.25 29.13,40.94 v2(29.13,38.78) ; UC1.A9 137.4,63.39 139.56,63.39 v2(139.99,63.81) v1(140.5,64.33) 140.87,64.7 RPC1.3
USB_OC1#: length 96.1
  IN2 w0.127: v2(152.75,62.35) 152.75,62.03 154.19,60.59 154.19,56.86 153.8,56.47 153.8,50.64 154.54,49.89 154.54,40.75 155.67,39.62 162.78,39.62 164.56,37.84 166.21,37.84 168.06,39.68 173.63,39.68 174.76,38.55 182.02,38.55 183.98,40.51 189.52,40.51 191.74,42.73 193.58,42.73 194.28,42.03 194.28,41.08 195.12,40.24 196.45,40.24 v2(197.06,39.63)
  BOTTOM w0.102: v2(197.06,39.63) UU3.3 ; v2(152.75,62.35) 152.75,63.5 v4(152.29,63.97) 151.7,64.55 151.7,65.56 150.08,67.17 147.96,67.17 147.42,66.63 144.97,66.63 144.5,66.16 144.5,64.38 144.31,64.2 RPC1.2 143.53,64.2 143.4,64.32 141.11,64.32 139.84,63.05 137.32,63.05 136.43,63.94 135.73,63.94 135.43,64.24 UC1.C9
USB_OC2#: length 11.3
  TOP w0.102: v2(138.91,62.61) 136.75,62.61 135.58,63.77 v2(134.4,63.77)
  BOTTOM w0.076: v2(134.4,63.77) 134.4,64.05 UC1.D9
  BOTTOM w0.102: RPC1.1 143.57,63.7 143.32,63.95 v1(142.59,63.95) 141.07,63.95 139.72,62.61 v2(138.91,62.61)
USB_OC3#: length 9.2
  BOTTOM w0.076: UC1.B9 136.1,64.45 136.29,64.45 136.41,64.5 136.84,64.5
  BOTTOM w0.102: RPC1.4 v1(141.77,65.2) 140.74,65.2 139.16,63.62 137.72,63.62 136.84,64.5
USB_PN1: length 124.5
  IN2 w0.089: 125.38,60.54 125.38,60.89 125.41,60.92 125.41,63.53 125.66,63.77 125.66,64.54 v2(125.76,64.65)
  IN2 w0.122: v2(25.12,48.52) 25.27,48.36 25.27,47.94 25.65,47.56 45.96,47.56 55.61,37.91 90.16,37.91 92.03,39.78 101.09,39.78 101.42,39.45 102.71,39.45 105.7,42.45 110.53,42.45 111.1,43.02 113.64,43.02 115.28,44.66 115.28,45.68 117.27,47.66 117.27,52.32 125.38,60.44 125.38,60.54
  BOTTOM w0.097: v2(125.76,64.65) 125.74,64.65 UC1.AB9 ; v2(25.12,48.52) 25.31,48.32 25.31,48.13 25.18,48 24.81,48 24.66,48.14 LU1.3 24.29,48.31 RU1.1
USB_PN1_R: length 13.1
  IN2 w0.122: v2(18.14,50.12) 18.06,50.04 17.71,50.04 17.43,50.32 17.43,52.54 16.7,53.27 16,53.27 15.88,53.4 JUSB1.2
  BOTTOM w0.097: RU1.2 23.38,48.31 LU1.4 22.98,48.14 22.82,47.99 22.55,47.99 20.58,49.95 20.17,49.95 20.07,50.05 20.07,50.7 EU2602.3 19.67,50.83 18.77,49.92 18.34,49.92 v2(18.14,50.12)
USB_PN2: length 161.1
  IN2 w0.122: v2(102.46,41.61) 102.46,41.61 102.8,41.95 103.74,41.95 105,43.2 109.47,43.2 110.97,44.7 113.23,44.7 116.52,47.98 116.52,53.13 123.14,59.75 123.45,59.75 124.72,61.02 124.72,61.9 v2(124.86,62.05) ; v2(169.05,35.05) 169.05,35.04 168.71,34.71 168.71,34.52 169.16,34.07 192.71,34.07 195.77,37.13 201.19,37.13 204.5,40.44 206.71,40.44 206.9,40.63 206.9,40.74 206.56,41.08 v2(206.56,41.08)
  BOTTOM w0.097: v2(124.86,62.05) 124.86,62.05 UC1.AD6 ; v2(169.05,35.05) 168.68,34.68 168.68,31.09 164.59,27 148.11,27 143.42,31.68 130.13,31.68 128.09,33.72 118.78,33.72 118.4,33.33 105.35,33.33 103.51,35.17 103.51,41.49 103.03,41.97 102.81,41.97 102.46,41.62 v2(102.46,41.61) ; RU15.1 206.44,40.06 LU9.3 206.6,40.5 206.83,40.73 206.83,40.83 206.58,41.08 v2(206.56,41.08)
USB_PN2_R: length 3.3
  BOTTOM w0.097: JIOB1.7 207.2,37.22 207.61,37.63 207.61,37.79 207.51,37.89 207.03,37.89 206.76,38.16 206.76,38.56 206.6,38.71 LU9.4 206.44,39.15 RU15.2
USB_PN3: length 130.5
  TOP w0.097: RU7.1 24.02,33.23 LU4.2 24.51,33.06 24.64,32.93 24.83,32.93 v2(24.98,33.08)
  IN2 w0.122: v2(24.98,33.08) 24.46,33.08 24.23,33.31 24.23,35.81 28.22,39.8 46.57,39.8 53.19,33.19 91.6,33.19 92.1,33.69 92.57,33.69 93.22,34.34 95.92,34.34 96.24,34.02 97.92,34.02 98.24,34.34 101.89,34.34 102.29,33.94 106.15,33.94 106.38,34.17 106.38,34.53 v2(106.46,34.61) ; v2(121.59,61.67) 121.48,61.56 120.63,61.56 120.61,61.58 119.86,61.58 119.56,61.28 119.36,61.28 118.18,60.09 117.56,60.09 116.43,58.96 116.43,57.69 116.19,57.45 115.68,57.45 113.87,55.64 111.96,55.64 107.77,51.45 107.77,48.21 107.22,47.67 107.22,46.61 107.17,46.56 106.88,46.56 v2(106.8,46.64)
  BOTTOM w0.076: UC1.AH3 121.59,61.4 v2(121.59,61.67)
  BOTTOM w0.097: v2(106.46,34.61) 106.27,34.8 106.27,36.76 106.46,36.95 106.46,42.46 107.41,43.42 107.41,46.4 107.26,46.55 106.88,46.55 v2(106.8,46.64)
USB_PN3_R: length 11.5
  TOP w0.097: RU7.2 23.11,33.23 LU4.1 22.62,33.06 22.44,32.88 21.57,32.88 21.5,32.95 21.5,33.46 21.29,33.66 EU2604.3 20.76,32.89 20.66,32.79 20.06,32.79 19.4,32.14 19.4,30.68 v3(18.84,30.12) 18.06,29.33 17.82,29.33 17.78,29.36 17.18,29.36 17.15,29.33 16.8,29.33 JUSB2.2
USB_PN5: length 113.4
  IN2 w0.122: v2(210.7,48.37) 210.45,48.12 210.45,47.21 200.87,37.63 195.28,37.63 193.14,35.5 170.23,35.5 170.16,35.42 170.16,35.24 v2(170.41,34.98)
  BOTTOM w0.097: UC1.AJ1 121.05,59.65 120.96,59.65 120.86,59.55 120.86,58.47 120.26,57.87 120.26,55.08 120.27,55.08 120.27,53.98 123.29,50.95 124.81,50.95 125.05,50.71 128.31,50.71 129.79,49.24 131.44,49.24 136.54,44.14 139.05,44.14 139.09,44.18 139.67,44.18 139.71,44.14 148.11,44.14 152.62,39.63 152.62,38.42 155.09,35.94 169.77,35.94 170.01,35.7 170.01,35.37 170.4,34.98 v2(170.41,34.98) ; R17.2 210.76,47.36 L3.4 210.6,47.79 210.41,47.98 210.41,48.09 210.69,48.37 v2(210.7,48.37)
USB_PN6: length 150.4
  IN2 w0.122: v2(208.34,41.08) 208.59,40.83 208.59,40.6 207.69,39.69 204.82,39.69 201.5,36.38 196.08,36.38 193.02,33.32 164.51,33.32 164.03,32.84 164.03,32 163.7,31.67 v2(163.7,31.66) ; v2(122.71,62.08) 122.71,62.2 122.56,62.36 122.31,62.36 122.19,62.23 122.19,61.39 120.66,59.87 119.44,59.87 118.66,59.08 118.66,57.82 117.29,56.45 116.09,56.45 113.28,53.64 111.37,53.64 108.77,51.03 108.77,47.8 108.22,47.25 108.22,47 v2(108.47,46.76)
  BOTTOM w0.089: v2(122.71,62.08) 122.71,62.19 123.04,62.52 123.16,62.52 123.23,62.45 UC1.AF6
  BOTTOM w0.097: RU13.1 208.21,40.06 LU8.3 208.38,40.49 208.6,40.7 208.6,40.85 208.36,41.08 v2(208.34,41.08) ; v2(163.7,31.66) 164,31.36 164,30.81 162.08,28.9 148.42,28.9 144.12,33.2 130.76,33.2 128,35.96 127.18,35.96 126.46,35.24 117.88,35.24 117.56,34.92 109.97,34.92 109.65,35.24 107.67,35.24 107.16,35.75 107.16,42.09 108.12,43.06 108.12,46.4 v2(108.47,46.76)
USB_PN6_R: length 4.4
  BOTTOM w0.097: RU13.2 208.21,39.15 LU8.4 208.38,38.78 208.54,38.62 208.54,38.24 208.88,37.89 209.1,37.89 209.13,37.86 209.82,37.86 209.92,37.76 210.5,37.76 210.6,37.67 210.6,37.53 210.2,37.14 JIOB1.4
USB_PN7: length 193.1
  IN2 w0.122: v2(143.35,89.09) 143.35,89.09 143.01,88.76 142.77,88.76 142.52,89 142.52,95.6 143.12,96.2 143.12,101.62 142.53,102.21 142.53,112.44 139.49,115.48 131.26,115.48 120.27,126.47 112.92,126.47 112.28,125.83 105.91,125.83 105.27,126.47 95.21,126.47 94.57,125.83 89.61,125.83 87.52,127.93 76.98,127.93 76.79,128.11 v2(76.79,128.11)
  BOTTOM w0.097: v2(76.79,128.11) 77.14,127.75 77.44,127.75 77.63,127.57 77.63,122.49 77.88,122.24 78.1,122.24 78.14,122.28 78.14,122.48 78.21,122.55 JWLAN1.5 ; UC1.AH1 121.72,59.96 121.64,59.96 121.55,59.87 121.55,58.58 120.93,57.95 120.93,55.08 120.93,55.08 120.93,54.26 123.23,51.96 124.75,51.96 125.33,51.38 128.59,51.38 128.79,51.18 132.75,51.18 135.48,53.91 139.18,53.91 139.43,53.66 141.57,53.66 145.51,49.72 150.33,49.72 152.18,51.57 152.18,59.82 153.23,60.88 153.23,63.7 152.18,64.75 152.18,65.78 151.58,66.39 151.58,78.34 149.39,80.52 149.39,81.34 148.05,82.67 144.68,82.67 143.04,84.32 143.04,87.5 142.71,87.83 142.71,88.51 142.9,88.7 142.97,88.7 143.35,89.08 v2(143.35,89.09)
USB_PN8: length 157
  IN2 w0.122: v2(106.71,45.22) 106.46,45.47 106.46,45.74 105.98,46.22 105.98,49.37 107.26,50.66 107.26,51.66 111.8,56.2 113.72,56.2 115.59,58.07 115.59,59.22 116.71,60.34 116.71,60.39 118.08,61.77 118.16,61.77 118.8,62.41 118.8,62.94 118.93,63.06 120.19,63.06 120.21,63.04 120.91,63.04 121.32,63.45 121.32,63.68 121.48,63.84 122.35,63.84 v2(122.71,63.49) ; v2(165.76,31.66) 165.84,31.74 165.84,31.75 166.07,31.98 166.07,32.24 166.4,32.56 193.33,32.56 195.25,34.48 206.02,34.48 207.58,36.04 208.76,36.04 210.58,37.86 210.58,38.04 210.24,38.37 v2(210.24,38.38)
  BOTTOM w0.097: v2(210.24,38.38) 210.46,38.6 210.46,38.79 210.29,38.96 L4.4 210.12,39.34 R20.2 ; v2(122.71,63.49) 122.71,63.58 122.89,63.76 123.09,63.76 UC1.AF8 ; v2(165.76,31.66) 166.16,31.27 166.16,29.77 164.61,28.23 148.15,28.23 143.84,32.54 130.48,32.54 128.45,34.57 118.43,34.57 118.04,34.19 105.7,34.19 105.25,34.63 105.25,36.89 105.79,37.42 105.79,43.06 106.25,43.52 106.25,44.42 106.39,44.56 106.39,44.89 v2(106.71,45.22)
USB_PN8_TPNL: length 9.1
  BOTTOM w0.097: R20.1 210.12,40.25 L4.3 210.29,40.66 210.44,40.82 210.44,40.97 210.35,41.06 209.65,41.06 209.08,41.63 209.08,42.01 208.95,42.14 208.34,42.14 DA6.3 208.33,42.46 208.81,42.46 208.91,42.56 208.91,42.76 209.63,43.49 210.66,43.49 211.35,42.79 211.8,42.79 211.95,42.95 JEDP1.36
USB_PN9: length 145.7
  IN2 w0.122: v2(220.48,37.82) 220.47,37.82 220.14,38.16 219.94,38.16 219.47,37.69 219.47,36.08 217.85,34.46 217.85,32.25 216.61,31.01 213.91,31.01 212.27,32.64 207.02,32.64 205.94,31.55 196.66,31.55 195.79,30.69 177.48,30.69 176.87,30.08 161.26,30.08 161.18,30 161.18,29.89 v2(161.42,29.65) ; v2(121.71,40.41) 121.51,40.61 121.51,41.24 121.64,41.36 121.64,51.27 123.65,53.28 123.8,53.28 124.13,52.95 v2(124.14,52.95)
  BOTTOM w0.076: UC1.AG1 122.43,59.65 122.5,59.72 122.58,59.72 122.69,59.62 122.69,59.41 122.67,59.38 122.67,58.55 122.81,58.41 122.81,55.28 122.7,55.17 122.7,55.08
  BOTTOM w0.097: v2(220.48,37.82) 220.68,38.02 220.91,38.02 221.14,37.79 221.14,37.27 221.04,37.17 220.26,37.17 220.18,37.08 EU2701.2 220.89,36.28 221.05,36.11 221.05,35.67 219.49,34.11 219.49,32.06 219.24,31.81 218.9,31.81 218.66,31.57 218.66,31.3 218.5,31.15 JFP1.6 ; v2(161.42,29.65) 161.13,29.94 161.13,30.06 160.94,30.25 148.01,30.25 144.4,33.87 135.51,33.87 132.05,37.33 123.42,37.33 121.31,39.44 121.31,40.02 121.7,40.41 v2(121.71,40.41) ; 122.7,55.08 122.7,53.91 123.27,53.34 123.74,53.34 v2(124.14,52.95)
USB_PP1: length 124.4
  IN2 w0.089: v2(124.94,64.57) 125.3,64.57 125.48,64.39 125.48,63.84 125.24,63.6 125.24,61 125.21,60.97 125.21,60.64 125.19,60.62 125.19,60.61 125.13,60.55 125.13,60.54
  IN2 w0.122: 125.13,60.54 125.13,60.54 117.02,52.42 117.02,47.77 115.03,45.78 115.03,44.76 113.54,43.26 110.99,43.26 110.43,42.7 105.6,42.7 102.6,39.7 101.53,39.7 101.2,40.03 91.93,40.03 90.05,38.16 55.71,38.16 46.06,47.81 25.75,47.81 25.52,48.04 25.52,48.35 v2(25.7,48.52)
  BOTTOM w0.097: RU2.1 24.29,47.47 LU1.2 24.69,47.64 24.86,47.81 25.26,47.81 25.5,48.06 25.5,48.32 v2(25.7,48.52) ; UC1.AB10 125.36,64.81 125.13,64.57 v2(124.94,64.57)
USB_PP1_R: length 13.2
  IN2 w0.122: JUSB1.3 15.88,52.9 16,53.03 16.6,53.03 17.18,52.44 17.18,50.22 17.61,49.79 17.89,49.79 v2(18.14,49.54)
  BOTTOM w0.097: RU2.2 23.38,47.47 LU1.1 22.98,47.64 22.82,47.8 22.47,47.8 20.5,49.77 20.17,49.77 20.07,49.67 20.07,49.02 EU2602.2 19.6,48.9 18.76,49.74 18.34,49.74 v2(18.14,49.54)
USB_PP2: length 161.1
  IN2 w0.122: v2(102.46,42.19) 103.64,42.19 104.89,43.45 109.37,43.45 110.87,44.95 113.13,44.95 116.27,48.09 116.27,53.24 123.03,60 123.35,60 124.47,61.12 124.47,62.24 v2(124.86,62.63) ; v2(168.46,35.05) 168.46,34.41 169.06,33.82 192.81,33.82 195.87,36.88 201.29,36.88 204.61,40.2 206.82,40.2 207.15,40.52 v2(207.15,41.08)
  BOTTOM w0.097: v2(124.86,62.63) UC1.AD7 ; v2(207.15,41.08) 207.02,40.95 207.02,40.58 207.1,40.5 LU9.2 207.27,40.06 RU16.1 ; v2(102.46,42.19) 102.5,42.16 103.11,42.16 103.7,41.57 103.7,35.25 105.43,33.52 118.32,33.52 118.71,33.91 128.17,33.91 130.2,31.87 143.5,31.87 148.19,27.19 164.51,27.19 168.49,31.17 168.49,35.02 v2(168.46,35.05)
USB_PP2_R: length 3.3
  BOTTOM w0.097: JIOB1.6 208.2,37.24 207.79,37.65 207.79,37.87 207.59,38.08 207.11,38.08 206.95,38.24 206.95,38.62 207.1,38.78 LU9.1 207.27,39.15 RU16.2
USB_PP3: length 130.3
  TOP w0.097: RU8.1 24.02,32.39 LU4.3 24.42,32.56 24.6,32.74 24.76,32.74 24.98,32.52 v2(24.98,32.49)
  IN2 w0.122: v2(105.88,34.61) 106.13,34.36 106.13,34.27 106.05,34.19 102.39,34.19 101.99,34.59 98.14,34.59 97.82,34.27 96.35,34.27 96.03,34.59 93.11,34.59 92.47,33.94 92,33.94 91.49,33.44 53.29,33.44 46.68,40.05 28.12,40.05 23.98,35.91 23.98,33.21 24.36,32.83 24.64,32.83 24.98,32.49 v2(24.98,32.49) ; v2(106.8,46.05) 107.05,46.31 107.27,46.31 107.47,46.51 107.47,47.57 108.02,48.11 108.02,51.35 112.06,55.39 113.97,55.39 115.78,57.2 116.29,57.2 116.68,57.59 116.68,58.86 117.67,59.84 118.28,59.84 118.8,60.36 118.8,60.42 119.45,61.07 119.65,61.07 119.95,61.37 120.53,61.37 120.66,61.24 v2(120.66,61.07)
  BOTTOM w0.076: UC1.AJ3 120.93,61.07 v2(120.66,61.07)
  BOTTOM w0.097: v2(105.88,34.61) 106.07,34.81 106.07,36.83 106.27,37.03 106.27,42.54 107.22,43.5 107.22,46.32 107.18,46.37 107.1,46.37 106.8,46.07 v2(106.8,46.05)
USB_PP3_R: length 11.6
  TOP w0.097: RU8.2 23.11,32.39 LU4.4 22.52,32.56 22.39,32.7 21.5,32.7 21.37,32.57 21.37,32.06 21.04,31.73 EU2604.2 20.76,32.51 20.66,32.6 20.13,32.6 19.59,32.06 19.59,30.6 19.21,30.22 19.21,30.18 18.79,29.75 18.74,29.75 18.13,29.14 v3(17.48,29.14) 16.77,29.14 JUSB2.3
USB_PP5: length 113.5
  IN2 w0.122: v2(210.12,48.37) 210.2,48.29 210.2,47.32 200.76,37.88 195.17,37.88 193.04,35.75 170.13,35.75 169.91,35.52 169.91,35.07 v2(169.83,34.98)
  BOTTOM w0.097: v2(169.83,34.98) 169.83,35.62 169.69,35.76 155.02,35.76 152.43,38.34 152.43,39.55 148.03,43.95 v3(139.38,43.95) 136.47,43.95 131.37,49.05 129.71,49.05 128.23,50.53 124.97,50.53 124.73,50.77 123.21,50.77 120.08,53.9 120.08,57.95 120.68,58.55 120.68,59.63 121.1,60.05 UC1.AJ2 ; R18.2 209.93,47.36 L3.1 210.1,47.79 210.22,47.91 210.22,48.27 v2(210.12,48.37)
USB_PP6: length 150.5
  IN2 w0.122: v2(107.89,46.76) 107.98,46.84 107.98,47.36 108.52,47.9 108.52,51.14 111.27,53.89 113.18,53.89 115.99,56.7 117.19,56.7 118.41,57.92 118.41,59.19 119.34,60.12 120.56,60.12 121.13,60.69 121.19,60.69 121.98,61.48 121.98,62.32 122.23,62.57 122.56,62.57 v2(122.71,62.72) ; v2(208.92,41.08) 208.84,41 208.84,40.49 207.79,39.44 204.92,39.44 201.6,36.13 196.19,36.13 193.12,33.07 164.61,33.07 164.28,32.73 v2(164.28,31.66)
  BOTTOM w0.089: UC1.AF7 122.98,62.72 v2(122.71,62.72)
  BOTTOM w0.097: RU14.1 209.05,40.06 LU8.2 208.88,40.5 208.78,40.6 208.78,40.94 v2(208.92,41.08) ; v2(164.28,31.66) 164.18,31.56 164.18,30.73 162.16,28.71 148.35,28.71 144.04,33.02 130.68,33.02 127.92,35.77 127.26,35.77 126.54,35.05 117.96,35.05 117.64,34.73 109.89,34.73 109.57,35.05 107.59,35.05 106.97,35.67 106.97,42.17 107.93,43.14 107.93,46.71 v2(107.89,46.76)
USB_PP6_R: length 4.5
  BOTTOM w0.097: JIOB1.3 211.2,37.1 210.78,37.52 210.78,37.75 210.58,37.95 209.99,37.95 209.86,38.08 v3(209.43,38.08) 208.96,38.08 208.73,38.32 208.73,38.62 208.88,38.78 LU8.1 209.05,39.15 RU14.2
USB_PP7: length 193.3
  IN2 w0.122: v2(76.79,127.53) 76.94,127.68 87.41,127.68 89.51,125.58 94.68,125.58 95.32,126.22 105.17,126.22 105.81,125.58 112.38,125.58 113.02,126.22 120.17,126.22 131.15,115.24 139.38,115.24 142.28,112.34 142.28,102.11 142.87,101.52 142.87,96.3 142.28,95.71 142.28,88.9 142.66,88.51 v2(143.35,88.51)
  BOTTOM w0.097: v2(76.79,127.53) 76.83,127.57 77.36,127.57 77.44,127.49 77.44,122.41 77.8,122.05 JWLAN1.3 ; v2(143.35,88.51) 143.04,88.51 142.98,88.51 142.9,88.43 142.9,87.91 143.22,87.58 143.22,84.4 144.76,82.86 148.13,82.86 149.58,81.41 149.58,80.6 151.76,78.41 151.76,66.46 152.37,65.86 152.37,64.83 153.42,63.78 153.42,60.8 152.37,59.75 152.37,51.49 150.4,49.53 145.43,49.53 141.49,53.47 139.36,53.47 139.11,53.72 135.56,53.72 132.83,50.99 128.71,50.99 128.51,51.19 125.25,51.19 124.67,51.77 123.15,51.77 120.74,54.18 120.74,58.03 121.37,58.65 121.37,60.17 UC1.AH2
USB_PP8: length 157.2
  IN2 w0.122: v2(106.13,45.22) 106.21,45.3 106.21,45.63 105.73,46.12 105.73,49.48 107.01,50.76 107.01,51.77 111.7,56.45 113.62,56.45 115.34,58.17 115.34,59.32 116.46,60.44 116.46,60.49 116.55,60.58 116.6,60.58 118.03,62.02 118.06,62.02 118.56,62.51 118.56,63.04 118.83,63.31 120.3,63.31 120.32,63.29 120.86,63.29 121.11,63.54 121.11,63.77 121.4,64.05 122.67,64.05 v2(122.71,64.09) ; v2(166.35,31.66) 166.32,31.69 166.32,32.14 166.5,32.31 193.44,32.31 195.35,34.23 206.12,34.23 207.68,35.79 208.86,35.79 210.83,37.75 v2(210.83,38.38)
  BOTTOM w0.097: v2(122.71,64.09) 122.84,63.97 122.92,63.97 UC1.AF9 ; v2(210.83,38.38) 210.71,38.49 210.71,38.89 210.79,38.96 L4.1 210.95,39.34 R21.2 ; v2(166.35,31.66) 166.35,29.7 164.69,28.04 148.08,28.04 143.77,32.35 130.4,32.35 128.37,34.38 118.51,34.38 118.12,34 105.62,34 105.07,34.56 105.07,36.97 105.6,37.5 105.6,43.14 106.06,43.6 106.06,44.5 106.2,44.64 106.2,45.15 v2(106.13,45.22)
USB_PP8_TPNL: length 9
  BOTTOM w0.097: R21.1 210.95,40.25 L4.2 210.79,40.66 210.63,40.82 210.63,41.04 210.42,41.25 209.73,41.25 209.27,41.71 209.27,42.02 209.39,42.14 209.94,42.14 DA6.2 209.95,42.46 209.19,42.46 209.09,42.56 209.09,42.68 209.71,43.3 210.58,43.3 211.27,42.61 211.8,42.61 211.96,42.45 JEDP1.37
USB_PP9: length 145.9
  IN2 w0.122: v2(124.14,53.53) 123.55,53.53 121.39,51.37 121.39,41.46 121.26,41.34 121.26,40.54 v2(121.13,40.41) ; v2(220.48,38.41) 219.84,38.41 219.22,37.79 219.22,36.19 217.6,34.56 217.6,32.35 216.5,31.26 214.01,31.26 212.38,32.89 206.92,32.89 205.83,31.8 196.56,31.8 195.69,30.94 177.37,30.94 176.76,30.33 161.15,30.33 160.93,30.1 160.93,29.74 v2(160.84,29.65)
  BOTTOM w0.076: UC1.AG2 122.77,59.9 122.77,59.77 122.86,59.69 122.86,59.34 122.83,59.32 122.83,58.62 122.98,58.48 122.98,55.21 122.89,55.13 122.89,55.08
  BOTTOM w0.097: v2(220.48,38.41) 220.68,38.21 220.99,38.21 221.33,37.87 221.33,37.32 221.43,37.22 221.99,37.22 222.11,37.1 EU2701.3 221.43,36.28 221.24,36.09 221.24,35.59 219.68,34.03 219.68,31.98 219.31,31.62 218.98,31.62 218.84,31.49 218.84,31.3 219,31.14 JFP1.5 ; v2(124.14,53.53) 123.35,53.53 122.89,53.99 122.89,55.08 ; v2(160.84,29.65) 160.94,29.75 160.94,29.98 160.86,30.07 147.93,30.07 144.32,33.68 135.44,33.68 131.97,37.14 123.34,37.14 121.13,39.36 v2(121.13,40.41)
USBCOMP: length 2.4
  TOP w0.102: RC66.1 126.54,63.88 v1(126.6,63.94)
  TOP w0.254: v2(125.79,62.7) 126,62.7 126.35,63.05 RC66.1
  BOTTOM w0.254: v2(125.79,62.7) 125.74,62.7 UC1.AB6
VCI_IN1: length 7.1
  TOP w0.102: UE1.126 36,78.08 35.4,78.68 34.85,78.68 34.48,79.05 34.48,80.6 34,81.08 34,81.55 RE70.1 33.61,82.65 v1(33.89,82.94)
VCIN0_PH: length 113.4
  TOP w0.102: v2(54.49,57.42) 53.15,57.42 R43.2 R42.2 52.01,57.37 52,57.35 C33.1 C32.1 ; v2(54.46,70.09) 54.42,70.13 RE37.2 ; RH1.1 124.01,53.98 v1(123.36,53.33) v2(123.36,52.4)
  IN1 w0.127: v2(54.49,57.42) 54.92,56.99 54.92,50.62 54.45,50.16 54.45,44.3 59.28,39.47 62.54,39.47 62.91,39.09 89.17,39.09 92.11,42.03 93.98,42.03 94.47,42.53 99.04,42.53 100.62,44.11 102.56,44.11 103.59,45.14 104.8,45.14 105.17,44.76 107.84,44.76 108.98,43.63 114.11,43.63 116.97,46.48 119.5,46.48 119.92,46.9 119.92,48.04 123.36,51.48 v2(123.36,52.4)
  BOTTOM w0.102: v2(54.49,57.42) 54.92,57.85 54.92,69.64 v2(54.46,70.09)
VCREF0: length 4.5
  TOP w0.102: UE1.25 32.31,66.03 v1(32.06,65.77) 31.66,65.38 CE23.1 RE48.1 RE46.2
VD_IN1_C: length 98.1
  TOP w0.102: v2(124.37,51.37) 124.37,52.12 124.88,52.62 RH1.2 ; v2(54.49,56.8) 53.8,56.8 R45.1 53.77,56.8 C33.2 C32.2 v1(52.91,54.85)
  IN1 w0.127: v2(124.37,51.37) 123.61,51.37 120.18,47.94 120.18,46.79 119.61,46.23 117.07,46.23 114.21,43.37 108.87,43.37 107.74,44.51 105.06,44.51 104.69,44.88 103.69,44.88 102.67,43.86 100.72,43.86 99.14,42.27 94.58,42.27 94.08,41.78 92.24,41.78 89.3,38.84 62.81,38.84 62.43,39.21 59.18,39.21 53.68,44.71 53.68,51.91 54.08,52.31 54.08,56.39 v2(54.49,56.8)
VGA_CBL_DET#: length 116.7
  TOP w0.102: JVGA.10 v2(218.75,34.25) ; v2(128.15,62.02) 127.82,61.68 127.57,61.68 127.19,61.3 RC207.1
  IN1 w0.127: v2(128.15,62.02) 128.26,62.02 129.65,60.62 134.19,60.62 135.26,61.69 137.86,61.69 139.24,60.31 141.63,60.31 141.8,60.14 142.38,60.14 144.76,57.76 148.8,57.76 150.24,56.32 150.24,48.54 152.15,46.62 152.15,46.25 154.83,43.57 158.74,43.57 160.38,41.93 170.14,41.93 173.05,39.02 174.52,39.02 175.18,38.36 178.06,38.36 178.36,38.67 186.57,38.67 187.36,39.45 191.69,39.45 192.33,38.82 195.7,38.82 v2(196.48,39.6)
  BOTTOM w0.076: UC1.U4 127.73,61.59 v2(128.15,62.02)
  BOTTOM w0.102: v2(196.48,39.6) 196.2,39.32 196.2,37.16 200.23,33.13 202.54,33.13 204.3,31.36 208.9,31.36 209.75,32.22 213.8,32.22 214.04,32.46 217.17,32.46 217.36,32.65 217.36,32.85 v1(218.23,33.72) v2(218.75,34.25)
VIDALERT_N: length 39.4
  TOP w0.102: PRZ41.2 v2(152.82,121.64)
  IN2 w0.127: v2(142.53,118.8) 144.24,118.8 148.25,122.81 151.65,122.81 v2(152.82,121.64)
  BOTTOM w0.102: RC153.2 RC152.2 141.72,95.85 142.14,96.27 142.88,96.27 143.47,96.86 143.47,100.43 143.01,100.89 143.01,106.23 142.86,106.38 v1(142.86,115.95) 142.86,118.09 142.76,118.19 142.76,118.58 v2(142.53,118.8) ; PRZ41.2 v2(152.82,121.64)
VIDSCLK: length 47.6
  TOP w0.102: PRZ40.2 v2(153.7,121.64)
  IN2 w0.127: v2(142.56,119.57) 144.18,119.57 148.01,123.4 151.95,123.4 v2(153.7,121.64)
  BOTTOM w0.102: PRZ40.2 v2(153.7,121.64) ; v2(142.56,119.57) 143.42,118.71 v1(143.42,117.1) 143.42,106.61 143.57,106.46 143.57,101.12 144.03,100.66 144.03,96.62 143.48,96.08 143.48,95.23 142.98,94.73 142.15,94.73 141.57,95.31 140.6,95.31 140.43,95.14 138.07,95.14 137.79,95.41 136.63,95.41 UC1.A63
VIDSOUT: length 44.9
  TOP w0.102: PRZ42.2 v2(151.93,121.64)
  IN2 w0.127: v2(151.93,121.64) 151.34,122.23 150.02,122.23 148.19,120.4 146.98,120.4 144.78,118.2 v2(141.96,118.2)
  BOTTOM w0.102: v2(141.96,118.2) 142.3,117.86 v1(142.3,113.77) 142.3,106.15 142.45,106 142.45,100.65 142.91,100.2 142.91,97.09 142.53,96.71 142.21,96.71 141.77,96.27 141.26,96.27 141.16,96.37 141.16,96.84 140.98,97.02 140.23,97.02 RC154.2 139.25,97.5 138.85,97.09 138.85,96.88 138.51,96.55 137.78,96.55 137.09,95.86 135.99,95.86 135.72,95.6 135.57,95.6 135.56,95.6 135.45,95.6 135.16,95.89 UC1.D64 ; PRZ42.2 v2(151.93,121.64)
VL: length 5.3
  BOTTOM w0.102: v1(164.19,136.84) 163.33,136.84 162.82,136.33 162.01,136.33 PC515.1
  BOTTOM w0.254: PC515.1 161.37,135.77 160.2,136.95 PU501.15
VR_CAP: length 6.6
  TOP w0.102: TP44.1 28.47,68.13 28.52,68.08 CE24.1 28.99,68.77 29.34,69.11 31.63,69.11 31.91,68.83 UE1.18
VR_HOTL#: length 2.1
  BOTTOM w0.102: PRZ49.1 151.23,119.85 151.23,119.1 151.01,118.89 PUZ01.31
VRALERT#: length 30.5
  TOP w0.102: v2(119.93,66.42) 119.93,65.73 118.54,64.34 118.54,62.55 118,62 117.67,62 117.11,61.45 117.11,60.68 v1(115.79,59.36) 115.37,58.93 115.37,53.93 118.01,51.29 118.01,49.41 118.46,48.95 119.24,48.95 119.87,48.32 119.87,43.61 120.29,43.19 120.29,42.9 120.38,42.82 120.38,41.73 120.23,41.58 RC92.1
  BOTTOM w0.102: UC1.AM11 120.29,66.07 v2(119.93,66.42)
VRMP_CPU: length 5
  BOTTOM w0.102: v1(145.56,108.99) 145.96,109.38 145.96,110.04 PRZ35.2
  BOTTOM w0.203: PRZ35.2 PCZ23.1 147.35,110.98 147.61,111.23 147.7,111.23 148.52,112.05 PUZ01.12
VSA_SEN+: length 87.2
  TOP w0.254: v2(132.23,70.94) 132.23,71.09 132.51,71.38 135.3,71.38 135.53,71.15 139.16,71.15 139.57,71.57 v2(143.84,71.57) 144.43,71.57 144.8,71.19 RC159.2 ; v2(158.31,112.88) 158.19,113.01 157.84,113.01 PRZ03.1
  IN1 w0.254: v2(158.31,112.88) 158.31,111 168.6,100.71 168.6,71.89 166.57,69.85 153.51,69.85 151.61,71.75 148.65,71.75 147.74,72.66 146.21,72.66 145.11,71.57 v2(143.84,71.57)
  BOTTOM w0.254: UC1.H20 132.23,70.84 v2(132.23,70.94)
VSA_SEN-: length 87.9
  TOP w0.254: v2(158.31,113.52) 158.25,113.45 157.91,113.45 PRZ07.1 ; RC160.1 v2(144.27,72.05) 144.19,72.12 139.52,72.12 139.32,71.92 135.7,71.92 135.31,72.31 132.59,72.31 132.52,72.31 132.19,71.99 v2(132.19,71.91)
  IN1 w0.254: v2(158.31,113.52) 158,113.52 157.77,113.28 157.77,111.01 168.22,100.55 168.22,72.04 166.41,70.23 153.67,70.23 151.7,72.19 148.88,72.19 148,73.07 146.06,73.07 145.04,72.05 v2(144.27,72.05)
  BOTTOM w0.102: v2(158.31,113.52) 158.64,113.52 v1(158.96,113.19)
  BOTTOM w0.254: v2(132.19,71.91) 132.19,71.72 UC1.H21
VSN_1A_CPU: length 4.8
  BOTTOM w0.102: PRZ52.1 v1(144.26,118.14)
  BOTTOM w0.203: PCZ28.1 146.77,118.14 147.13,118.5 148.46,118.5 148.61,118.36 PUZ01.25
  BOTTOM w0.254: PCZ28.1 PRZ52.1
VSN_1A_CPU_R: length 6.1
  TOP w0.254: v2(147.17,119.17) 147.17,119.99 146.9,120.26 PCZ29.1 146.45,120.25 PRZ53.1
  BOTTOM w0.102: v1(143.8,119.36) 144.4,119.36 144.71,119.05 PRZ52.2
  BOTTOM w0.254: PRZ52.2 PCZ28.2 146.26,119.17 v2(147.17,119.17)
VSN_1B_CPU: length 3
  BOTTOM w0.203: PUZ01.44 154.85,114.5 v1(154.95,114.41) 155.04,114.5 155.76,114.5 PCZ07.2
  BOTTOM w0.254: PRZ08.2 PCZ07.2
VSN_2PH_CPU: length 3.9
  TOP w0.254: PCZ11.2 PRZ19.2 155.29,111.9 v1(154.96,112.24) 154.89,112.31 v2(154.28,112.31)
  BOTTOM w0.203: PUZ01.48 154.19,112.9 154.28,112.82 v2(154.28,112.31)
VSN_2PH_CPU_R: length 3.8
  TOP w0.102: v2(156.87,110.1) v1(157.48,110.1)
  TOP w0.254: PRZ19.1 PCZ11.1 156.84,110.07 v2(156.87,110.1)
  BOTTOM w0.254: v2(156.87,110.1) PRZ18.2 156.18,110.96 PCZ10.2
VSNN_1B_CPU_R: length 5.2
  TOP w0.254: PRZ07.2 156.74,113.95 157.13,114.34 v2(157.54,114.34)
  BOTTOM w0.102: v1(158.89,114.51) 158.53,114.16 158.07,114.16 157.89,114.34 v2(157.54,114.34)
  BOTTOM w0.254: PCZ07.1 PRZ08.1 157.65,113.71 PCZ06.2 157.67,114.21 v2(157.54,114.34)
VSP_1A_CPU: length 3.5
  TOP w0.102: v2(147.48,117.79) v1(147.48,117.18)
  TOP w0.254: PCZ35.2 146.45,117.58 PRZ58.2 146.69,117.79 v2(147.48,117.79)
  BOTTOM w0.203: v2(147.48,117.79) 147.34,117.65 147.34,117.4 147.44,117.3 PUZ01.24
VSP_1A_CPU_R: length 3.6
  TOP w0.102: PRZ58.1 v1(147.44,118.48)
  TOP w0.254: PRZ59.2 145.6,119.35 PCZ29.2 PRZ58.1 146.45,118.47 PRZ61.1
VSP_1B_CPU: length 5.6
  BOTTOM w0.102: PRZ04.2 155.85,111.81 156.19,111.46 156.55,111.46 156.7,111.31 156.7,111.16 v1(157.13,110.73)
  BOTTOM w0.203: PCZ04.2 155.8,112.82 155.29,113.33 155.29,113.69 155,113.98 154.64,113.98 154.52,114.1 PUZ01.45
  BOTTOM w0.254: PCZ04.2 PRZ04.2
VSP_2PH_CPU: length 4.1
  BOTTOM w0.203: PUZ01.47 154.3,113.3 154.92,112.68 v1(154.92,112.2) 154.92,111.33 PCZ10.1
  BOTTOM w0.254: PCZ10.1 155.29,110.96 PRZ14.2
VSPP_1B_CPU_R: length 4.3
  TOP w0.254: v2(157.16,111.29) 157.16,111.45 v1(156.74,111.87) PRZ03.2
  BOTTOM w0.254: PCZ06.1 157.65,112.82 PCZ04.1 PRZ04.1 157.16,111.54 v2(157.16,111.29)
VTTREF_1.2V: length 4.3
  BOTTOM w0.102: PCM19.1 98.59,132.52 99.09,133.03 v1(100.41,133.03)
  BOTTOM w0.203: PCM19.1 98.08,132.09 97.37,132.09 97.08,132.37 PUM01.4
WHITE_LED_BAT: length 3.7
  BOTTOM w0.102: v1(11.59,121.78) 11.41,121.95 C41.1
  BOTTOM w0.254: C41.1 R69.2 Q19.1
WIFI_RF_EN: length 289.5
  TOP w0.102: RW11.1 68.28,135.2 v2(68.68,134.81)
  IN1 w0.127: v2(28.67,39.3) 28.67,47.11 27.66,48.13 27.66,72.83 25.43,75.05 25.43,78.08 23.57,79.94 20.35,79.94 19.08,81.21 19.08,88.07 17.81,89.34 17.81,102.32 19.01,103.51 22.59,103.51 24.35,105.28 24.35,120.07 31.4,127.12 51.8,127.12 60.1,135.42 68.06,135.42 v2(68.68,134.81)
  IN2 w0.127: v2(28.67,39.3) 44.65,39.3 48.25,35.7 49.96,35.7 52.98,32.68 92.27,32.68 93.43,33.83 95.71,33.83 96.03,33.51 98.21,33.51 98.53,33.83 101.68,33.83 102.08,33.44 110.06,33.44 110.48,33.86 119.19,33.86 119.5,34.17 129.89,34.17 134.63,38.9 134.63,42 140.59,47.97 140.59,50.85 137.92,53.51 137.92,56.92 138.64,57.63 139.84,57.63 140.08,57.88 v2(140.08,61.15)
  BOTTOM w0.076: UC1.B7 135.9,62.95 136.08,62.76 136.65,62.76 138.27,61.15 v2(140.08,61.15) 141.02,62.09 RC3.1
XCLK_BIASREF: length 8.1
  BOTTOM w0.076: UC1.E42 134.21,82.9 134.21,81.47 134.37,81.3 137.03,81.3 138.11,82.38 v1(138.69,82.38) RC76.1
XDP_HOOK0: length 1
  TOP w0.102: RC148.2 100.99,60.21 TPC32.1
XDP_ITP_PMODE: length 8.8
  BOTTOM w0.076: RC143.2 140.09,62.16 TPC7.1 137.51,62.16 136.84,62.83 136.84,63.27 136.72,63.4 134.21,63.4 133.82,63.78 UC1.E8
XDP_OBS0_R: length 2.6
  BOTTOM w0.076: UC1.C55 135.69,91.06 136.83,91.06 137.25,90.64 137.83,90.64 137.85,90.66 TP15.1
XDP_OBS1_R: length 5.4
  BOTTOM w0.076: UC1.D55 135.16,90.94 135.45,90.65 135.69,90.65 135.93,90.88 136.78,90.88 137.35,90.31 138.26,90.31 TP16.1
XDP_OBS2_R: length 2.9
  BOTTOM w0.076: UC1.B54 136.22,90.7 136.72,90.7 137.47,89.95 137.47,89.82 TP17.1
XDP_OBS3_R: length 5
  BOTTOM w0.076: UC1.C56 135.51,91.24 136.89,91.24 137.32,90.81 137.63,90.81 137.95,91.12 139.04,91.12 139.23,90.94 TP18.1
XDP_PRDY#: length 3.7
  BOTTOM w0.076: UC1.D56 134.92,91.72 135.05,91.85 135.94,91.85 135.98,91.9 136.33,91.9 136.4,91.93 136.77,91.93 136.96,91.74 137.44,91.74 TPC31.1
XDP_PREQ#: length 1.2
  TOP w0.102: TPC30.1 134.07,94.17 v2(134.07,93.82)
  BOTTOM w0.076: v2(134.07,93.82) 134.23,93.98 UC1.D61
XDP_PRSENT_CPU: length 1.8
  BOTTOM w0.102: RC175.2 RC144.1 141.24,102.59 TPC33.1
XDP_SPI_IO2: length 1.8
  BOTTOM w0.102: RC41.1 114.12,55.4 RC145.1 113.37,55.39 TPC9.1
XDP_SPI_SI: length 2
  BOTTOM w0.102: TPC8.1 109.93,54.57 RC40.1 RC139.2
XTAL24_IN: length 6.7
  BOTTOM w0.102: UC1.E37 134.2,80.17 135.22,80.17 135.22,80.16 137.19,80.16 137.71,79.64 v1(138.54,79.64) 138.92,79.26 RC23.1
XTAL24_IN_R: length 5.4
  BOTTOM w0.102: YC1.3 144.56,78.67 142.88,78.67 CC6.1 142.36,79.19 RC80.2 141.62,79.26 RC23.2
XTAL24_OUT: length 6.7
  BOTTOM w0.102: UC1.E35 134.04,79.41 136.71,79.41 136.71,79.4 137.03,79.4 137.03,79.41 137.35,79.41 138.31,78.44 v1(139.02,78.44) 139.92,78.44 RC24.1
XTAL24_OUT_R: length 3.4
  BOTTOM w0.102: YC1.1 143.23,77.54 142.5,78.27 CC7.1 142.41,78.28 RC80.1 141.6,78.37 RC24.2
N17003752: length 3.6
  TOP w0.102: v2(72.67,79.3) 72.34,78.98 v1(72.22,78.98) 71.59,78.98 71.54,78.93 RD23.2
  BOTTOM w0.102: v2(72.67,79.3) 72.35,78.99 JDIMM1.134
N17004366: length 3.7
  TOP w0.102: RD24.2 v1(57.69,79.63) 57.3,79.24 v2(56.9,79.24)
  BOTTOM w0.102: JDIMM2.134 57.15,78.99 v2(56.9,79.24)
N17237617:
  vias: v1(189.43,50.02) v2(188.86,48.68) v2(189.44,48.68) v2(190.03,48.68) v2(191.68,49.97) v2(191.68,49.33)
N17268429: length 3.9
  TOP w0.102: PQB05.1 205.36,49.39 v1(206.26,49.39)
  TOP w0.254: PQB05.1 204.46,48.48 204.35,48.48 204.34,48.47 204.31,48.47 PRB31.1 203.68,47.84 PRB30.2
N17283936: length 36.4
  TOP w0.381: RA5.1 23.08,6.52 RA6.1 v2(23.14,5.6) ; QA1.3 41.39,23.76 v1(38.92,21.29) 38.01,20.38 38.01,15.68 v2(38.52,15.17)
  BOTTOM w0.381: v2(38.52,15.17) 38.52,13.01 38.01,12.5 36.99,12.5 36.23,11.74 36.23,8.57 31.66,4 25.69,4 24.09,5.6 v2(23.14,5.6)
N17389450: length 57.6
  IN1 w0.127: v2(161.18,140.84) 161.18,141.9 158.05,145.03 152.88,145.03 150.4,142.55 114.03,142.55 v2(113.77,142.81)
  BOTTOM w0.102: PR508.1 v1(112.38,143.92)
  BOTTOM w0.254: v2(113.77,142.81) PD501.2 PC516.1 ; PR506.2 162.2,140.02 PR503.2 161.39,140.64 v2(161.18,140.84) ; PC516.1 PR502.2 ; PC516.1 PR508.1
N17415515: length 0.5
  TOP w0.102: v2(79.16,145.3) v1(79.16,144.76)
N17442062: length 2.3
  TOP w0.102: CZ3.1 146.26,68 146.26,67.29 v2(146.34,67.22) 146.54,67.01 UZ1.6
N17462309: length 3.2
  TOP w0.102: JDEG1.9 42,93.53 41.66,93.18 v1(40.77,93.18) 40.39,92.8 RE58.2
N17462311: length 4.7
  TOP w0.102: v1(49.06,93.91) 48.5,93.91 47.74,93.16 RE59.2 46.93,92.67 46,93.6 JDEG1.1
N17462343: length 8
  TOP w0.102: v2(113.74,30.2) v1(113.74,30.77)
  BOTTOM w0.102: v2(113.74,30.2) 113.45,30.49 RE65.2 112.33,31.22 108.25,31.22 107.57,30.55 JESPI1.8
N17569402: length 5.4
  TOP w0.102: UA1.4 33.25,12.25 33.47,12.02 35.21,12.02 RA9.1 35.87,12.28 37.45,12.28 v1(37.78,11.95)
N17772976: length 12.9
  TOP w0.508: v2(176.21,58.07) 176.41,57.87 v1(178.11,57.87) 178.32,58.07 PRB04.1 ; PQB11.4 180.77,63.44 v2(181.26,63.94)
  IN1 w0.508: v2(181.26,63.94) 176.21,58.89 v2(176.21,58.07)
N18346546: length 3.5
  TOP w0.102: Q13.1 105.25,29.32 105.89,29.95 v1(106.18,29.95) 106.24,30.01 R37.1
N18346552: length 9.6
  TOP w0.102: Q13.2 104.29,25.18 104.11,25 101.34,25 Q12.2 99.38,25.14 98.56,25.14 C18.2 R38.2 v1(96.51,25.3)
N18346555: length 7.4
  TOP w0.102: Q12.3 101.16,27.11 100.12,27.11 99.6,26.59 99.6,26.03 99.22,25.65 98.96,25.65 C18.1 R35.2 97.59,27.14 v1(97.4,27.33)
N18390627: length 3.2
  TOP w0.102: PQB07.1 v1(175.42,34.53)
  TOP w0.254: PQB07.1 175.4,35.73 PQB08.2
N18618528: length 5.9
  TOP w0.102: v2(113.45,61.19) 114.73,61.19 TP28.1
  BOTTOM w0.076: UC1.AY4 114.94,61.88 114.31,61.88 114.07,61.63 113.68,61.63 113.45,61.4 v2(113.45,61.19)
N18618529: length 4.4
  TOP w0.102: TP29.1 115.32,60.34 v2(113.25,60.34)
  BOTTOM w0.076: UC1.BB3 113.8,60.71 113.53,60.43 113.34,60.43 v2(113.25,60.34)
N18618530: length 5.9
  BOTTOM w0.102: UC1.BB5 113.8,62 113.35,62 112.14,60.8 112.14,59.91 110.61,58.38 TP27.1
N18855880: length 5.5
  TOP w0.102: R57.2 v1(217.83,57.62)
  TOP w0.203: U1.3 221.96,56.94 221.52,57.38 219.1,57.38 R57.2
N18983262: length 1.9
  TOP w0.102: RE67.1 CE35.2 44.92,57.65 v1(44.76,57.49)
N18984098: length 2.8
  TOP w0.102: v1(38.41,13.93) 38.41,13.49 CA38.2 37.68,12.76 RA43.1
N19485707: length 2.6
  BOTTOM w0.102: UX1.27 113.4,37.28 RX5.1 113.04,36.92 v1(113.04,35.92)
N19525376: length 10.8
  TOP w0.102: v1(116.73,40.42) 116.49,40.17 v2(116.03,40.17)
  TOP w0.508: v2(113.95,44.27) 114.52,43.7 114.52,43.3 115.16,42.67 115.16,41.73 CX6.1 CX7.1 115.1,40.11 RX7.2 RX6.2 116.03,39.42 v2(116.03,40.17)
  BOTTOM w0.254: UX1.14 113.4,43.83 113.84,44.27 v2(113.95,44.27) ; UX1.22 116.03,40.17 v2(116.03,40.17) 116.49,39.71 CX5.1
N20558038: length 4.8
  TOP w0.102: UC6.2 120.25,38.54 CC14.1 RC103.2 119.91,39.48 DZ4.2 v1(119.03,37.69)
