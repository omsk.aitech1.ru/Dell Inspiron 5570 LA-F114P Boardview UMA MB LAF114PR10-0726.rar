# Allegro board UMA MB_LAF114PR10-0726.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N21174101: length 2.8
  TOP w0.102: v2(164.88,38.6) v1(164.88,39.28)
  TOP w0.254: v2(164.88,38.6) PR39.1
  BOTTOM w0.254: v2(164.88,38.6) 164.95,38.68 PBATT1.5
N21222441: length 2.2
  BOTTOM w0.102: PRB27.2 196.44,45.15 v1(197.25,44.34)
N21242279: length 7
  TOP w0.254: PQB03.3 184.22,67.08 v1(185.62,65.68) 185.85,65.45 185.85,64.08 185.58,63.81 PRB03.1
N21269026: length 1.5
  TOP w0.102: PRI23.2 v1(156.69,100.78)
N21273981: length 1.7
  TOP w0.102: PRG03.2 v1(147.7,131.19)
N21380741:
  vias: v2(160.38,135.24)
N21389189:
  vias: v1(169.19,46.81) v2(169.07,47.48) v2(169.68,47.48) v2(170.15,47.1) v2(170.15,46.49)
N22794228: length 3.2
  TOP w0.102: 190.47,35.62 190.34,35.49 QS1.5 ; 190.47,35.62 190.47,36 190.33,36.14 QS1.6 ; 190.47,35.62 190.67,35.42 RS3.2 v1(192.05,35.42)
N22795667: length 5.1
  BOTTOM w0.102: RS5.1 178.27,40.95 178.27,39.29 177.07,38.1 US2.3
N22796700: length 6.7
  TOP w0.102: U3.3 213.31,42.8 213.83,43.32 213.83,45.83 v1(213.34,46.32) 212.38,47.28 R30.1
N22856216: length 4.7
  TOP w0.102: UL1.27 21.85,86.21 21.19,86.88 21.19,87.54 20.38,88.35 19.52,88.35 TP48.1
N22856217: length 1.9
  TOP w0.102: UL1.25 22.41,87.29 22.08,87.61 v2(21.6,87.61)
  BOTTOM w0.102: v2(21.6,87.61) 21.78,87.61 22.02,87.37 TP49.1
N22856235: length 3.5
  TOP w0.203: UL1.31 21.85,84.61 21.69,84.45
  TOP w0.254: RL2.2 21.01,82.88 v1(21.22,83.09) 21.69,83.56 21.69,84.45
N22856250: length 5.4
  TOP w0.102: v1(26.64,96.5) UL2.3 26.64,98.8 26.02,99.42 RL7.2
N22965608: length 1.5
  BOTTOM w0.102: UX1.2 108.58,39.67 RX8.1
N23213635: length 22.4
  TOP w0.102: v2(113.19,58.16) 113.84,58.16 114.13,58.45 114.49,58.45 v1(114.63,58.31) 114.91,58.03 114.91,53.68 117.51,51.08 117.51,42.55 RC197.1
  BOTTOM w0.076: UC1.AY3 114.9,60.57 114.49,60.57 114.23,60.32 114.23,59.93 113.19,58.9 v2(113.19,58.16)
N23213778: length 6.4
  BOTTOM w0.076: RC198.1 112.8,105.02 v1(112.11,105.02)
  BOTTOM w0.254: UC1.AY71 115.03,100.78 113.24,102.57 RC198.1
N23239464: length 22.2
  IN2 w0.254: v2(10.5,120.2) 10.5,130.95 8.05,133.4 5.68,133.4 5.29,133 2.8,133 2.42,132.62 v2(2.42,132.44)
  BOTTOM w0.102: v2(10.5,120.2) v1(10.5,120.76)
  BOTTOM w0.254: v2(2.42,132.44) 2.42,131.98 LED1.4 ; R68.1 v2(10.5,120.2)
N23239466: length 18.2
  IN1 w0.254: v2(3.08,132.45) 4.7,132.45 5.65,133.4 8.05,133.4 9.81,131.63 v2(9.81,123.63)
  BOTTOM w0.102: R69.1 v1(10.5,124.62)
  BOTTOM w0.254: LED1.2 3.25,132.28 v2(3.08,132.45) ; v2(9.81,123.63) R69.1
N23484620: length 2.7
  BOTTOM w0.203: PRB39.1 200.91,47.34 v1(200.88,47.34) 200.88,47.37 200.58,47.67 PUB01.12
N23574846: length 4.6
  BOTTOM w0.102: v1(201.41,44.53) 201.41,44.99 201.33,45.07 201.33,45.96 PRB40.2
  BOTTOM w0.203: PUB01.13 200.18,47.58 200.47,47.29 200.47,47.05 200.85,46.67 PRB40.2
N23700319: length 10
  TOP w0.102: v1(80.74,145.97) 82.04,147.26 PQ1.1
  TOP w0.254: PL3.2 83.51,144.76 82.6,144.76 PD1.2 82.58,147.26 PQ1.1 PR3.1
N23938731: length 16.3
  TOP w0.102: UE1.21 v2(34.95,67.63) ; v2(29.88,79.31) 30.31,79.74 RE81.1
  IN1 w0.127: v2(29.88,79.31) 30.26,78.93 30.26,76.77 33.44,73.59 33.44,69.15 v2(34.95,67.63)
N24339159: length 1.4
  TOP w0.076: v2(119.31,66.36) 119.24,66.29 TP76.1
  BOTTOM w0.076: UC1.AN11 119.31,66.24 v2(119.31,66.36)
N24339162: length 1.2
  TOP w0.076: v2(119.31,67.27) 119.59,67.56 TP77.1
  BOTTOM w0.076: v2(119.31,67.27) 119.31,67.15 UC1.AN13
N24516732: length 2.7
  BOTTOM w0.102: v1(108.57,41.49) RX9.1 108.91,40.17 UX1.3
N24516766: length 3.4
  BOTTOM w0.102: UX1.29 112.4,37.81 112.11,37.52 111.6,37.52 111.36,37.28 RX10.1 111.36,36.41 111.13,36.18 v1(111.13,35.82)
N24625686: length 7.9
  TOP w0.254: R74.2 62.35,27.69 v1(61.71,27.69) 56.34,27.69 Q24.1
N24625731: length 4.7
  TOP w0.102: Q24.2 54.14,29.57 R76.1 53.74,29.84 C39.1 52.94,30.62 D7.2 v1(53.25,32.14)
N24644647: length 3.4
  TOP w0.102: v1(69.2,136.51) RW11.2 v2(69.82,135.44)
  BOTTOM w0.102: JWLAN1.56 70.48,135.3 70.34,135.44 v2(69.82,135.44)
N24644650: length 3.6
  TOP w0.102: v2(69.89,134.8) 70.06,134.8 RW12.2 v1(70.7,136.43)
  BOTTOM w0.102: JWLAN1.54 v2(69.89,134.8)
N24646002: length 3.7
  TOP w0.102: v1(52.23,53.58) R67.1 R65.2 51.09,52.43 Q15.2
N24646039: length 2.4
  TOP w0.102: Q4.1 53.45,52.31 R67.2 53.15,53.09 v1(53.63,53.58)
N24646397: length 29.5
  TOP w0.102: v2(50.51,72.37) 50.45,72.43 UE1.88 ; v1(51.34,47.02) 51.34,47.2 v2(51.9,47.76) RE91.2 RE92.2
  IN1 w0.127: v2(50.51,72.37) 50.51,71.79 52.68,69.62 52.68,50.96 52.08,50.36 52.08,47.94 v2(51.9,47.76)
N24938879: length 3
  TOP w0.102: R77.1 37.12,23.47 v1(37.12,24.65) v2(37.12,25.33)
  BOTTOM w0.102: JSSD1.10 v2(37.12,25.33)
N25012168: length 3.9
  BOTTOM w0.102: Q25.5 28.18,122.06 27.9,121.78 27.9,121.57 28.07,121.41 Q25.6 28.63,121.39 R79.2 29.55,121.9 v1(29.98,122.33)
N25133961: length 2.7
  BOTTOM w0.102: v1(26.16,108.99) DI1.3 24.72,108.97 RI13.2
N25133963: length 4.3
  BOTTOM w0.102: v1(26.08,110.29) DI1.2 24.08,109.65 24.08,108.01 RI14.2
N27266810: length 22.2
  TOP w0.508: PCB02.2 181.95,65.16 181.3,65.8 PQB03.1 180.16,66.43 PRB07.1 179.85,65.21 PCB01.2 180.02,65.18 v2(180.63,64.57) ; PQB12.4 181.83,58.31 181.48,58.31 181.24,58.07 PRB04.2 180.62,57.45 180.37,57.21 v1(176.06,57.21) v2(175.29,57.97)
  IN1 w0.508: v2(180.63,64.57) 175.29,59.24 v2(175.29,57.97)
N27286345: length 3.5
  BOTTOM w0.102: v1(192.55,43.87) PDB01.1
  BOTTOM w0.508: PDB01.1 193.77,43.88 PRB27.1
N28424999: length 5.2
  BOTTOM w0.076: TP30.1 114.85,103.73 114.85,103.73 114.78,103.81 114.37,103.81 114.13,103.56 114.13,102.27 115.64,100.76 115.64,100.26 UC1.AW71
N28425002: length 4.8
  BOTTOM w0.076: UC1.AW70 115.2,99.81 115.4,100.02 115.4,100.77 113.75,102.42 TP31.1
N28483977: length 3.7
  TOP w0.102: PR35.2 v1(121.14,137.22)
  TOP w0.254: PR35.2 PR45.1 ; PR45.1 PR31.2 ; PR45.1 121,139.21 PQ13.2
N28483985: length 3.3
  TOP w0.102: PR32.2 123.35,139.26 v1(122.97,138.88)
  TOP w0.254: PR32.2 121.84,140.22 PQ13.3
N28484391: length 3.3
  TOP w0.102: v1(119.24,140.9) 118.87,140.53 PR33.2
  TOP w0.254: PQ12.6 118.12,140.24 117.98,140.1 PC13.1 PR33.2
N28484395: length 3.4
  TOP w0.102: v1(117.98,137.75) PC13.2
  TOP w0.254: PQ12.5 117.47,140.23 117.1,139.86 PR40.1 117.1,139.64 PC13.2
N28484412: length 4.4
  TOP w0.102: v1(115.64,141.89) 117.24,141.89 117.47,142.12 PQ12.2 117.47,143.19 117.5,143.21 PR36.2 PR44.2
N28484439: length 3.3
  TOP w0.102: v1(32,60.16) 31.64,59.8 PC14.2 PR43.1 30.07,59.73 PQ11.2
N28484451:
  vias: v1(119.91,143.39)
N28714500: length 2.9
  TOP w0.102: v1(204,51.7) 203.82,51.52 v2(203.43,51.52)
  BOTTOM w0.203: PRB17.2 204.03,52.38 203.56,51.92 203.56,51.66 v2(203.43,51.52) 203.17,51.52 202.91,51.26 PUB01.3
N28714504: length 1.9
  BOTTOM w0.203: PUB01.4 202.97,50.86 203.18,51.06 203.62,51.06 PRB18.2
N28714524: length 5.6
  BOTTOM w0.102: v1(199.82,57.74) PCB13.1
  BOTTOM w0.203: PCB13.1 199.14,55.08 199.14,53.85 199.78,53.22 PUB01.27
N28714534: length 4.1
  BOTTOM w0.102: v1(205.44,45.25) 204.58,44.38 203.97,44.38 203.46,44.89 PCB30.1
  BOTTOM w0.254: PRB38.2 202.66,45.58 PCB30.1
N28714559: length 1.8
  BOTTOM w0.203: PRB20.2 203.7,50.06 PUB01.6
N28714562: length 2
  BOTTOM w0.203: PRB23.2 203.78,48.83 v2(203.27,49.34) 202.95,49.66 PUB01.7
N28714564: length 1.3
  BOTTOM w0.102: PRB15.2 v1(195.23,55.24)
N28714583: length 3.9
  TOP w0.102: v1(200.61,47.54) 200.36,47.54 v2(199.96,47.14)
  TOP w0.254: v2(199.96,47.14) 199.96,46.52 PCB32.2
  BOTTOM w0.203: PRB41.2 200.07,47.04 v2(199.96,47.14) 199.78,47.33 PUB01.14
N28714585: length 3.6
  TOP w0.102: v1(199.34,47.71) 199.3,47.67 v2(199.3,47.18)
  TOP w0.254: v2(199.3,47.18) 199.16,47.04 PCB32.1
  BOTTOM w0.203: PUB01.15 199.38,47.26 v2(199.3,47.18) PRB34.2
N28714598: length 2.6
  BOTTOM w0.203: PUB01.31 201.38,53.12 201.46,53.2 v2(201.46,53.65) 201.46,54.28 PCB11.2 201.32,55.22 PRB06.2
N28714599: length 3.4
  BOTTOM w0.203: PRB05.2 202.23,55.22 PCB11.1 202.23,54.31 v2(202.75,53.79) 202.75,53.58 202.45,53.27 202.04,53.27 201.78,53.01 PUB01.32
N28714601: length 1.8
  BOTTOM w0.203: PCB13.2 200.01,54.16 v2(200.01,53.65) 200.01,53.62 200.18,53.45 PUB01.28
N28714604: length 22.1
  TOP w0.508: v2(184.91,51.78) 183.96,51.78 v1(183.21,52.53) 181.9,53.84 PRB12.1
  IN1 w0.508: v2(198.58,53.27) 196.8,55.05 186.34,55.05 184.91,53.62 v2(184.91,51.78)
  BOTTOM w0.203: PUB01.25 198.98,53.08 198.79,53.27 v2(198.58,53.27)
N28714606: length 8.2
  TOP w0.102: v2(186.91,51.81) v1(187.45,51.81)
  IN2 w0.762: 195.2,52.51 191.45,52.51 190.75,51.81 187.8,51.81
  vias: v2(186.28,51.81) v2(195.93,52.95) v2(195.93,52.32)
N28714608: length 3.5
  BOTTOM w0.102: v1(197.6,55.44) PRB10.2
  BOTTOM w0.203: PRB10.2 198.64,53.89 199.38,53.15 PUB01.26
N28714612:
  vias: v1(197.63,53.73)
N28714614: length 3.3
  BOTTOM w0.203: PRB25.1 197.72,46.5 v1(197.72,47.43) 197.72,48.99 197.99,49.26 PUB01.17
N28714617: length 1.3
  TOP w0.102: 187.71,57.49 v1(189.02,57.49)
N28714625: length 2.3
  TOP w0.102: PRB26.1 v1(196.64,45.52)
  TOP w0.254: v2(197.65,44.89) 197.63,44.9 PRB26.1
  BOTTOM w0.254: PRB25.2 v2(197.65,44.89)
N28714693: length 1.8
  TOP w0.102: v2(181.2,51.68) v1(181.2,51.13)
  TOP w0.508: v2(181.2,51.68) 180.89,51.99 PCB14.2
N28714721: length 31.9
  IN1 w0.254: v2(176.69,50.1) 176.82,49.97 176.82,45.65 180.12,42.35 186.22,42.35 186.65,42.78 192.87,42.78 195.49,45.4 198.79,45.4 v2(199.3,44.89)
  BOTTOM w0.254: PRB34.1 v2(199.3,44.89) ; PRB01.2 177.01,50.46 176.69,50.14 v2(176.69,50.1)
N28714724: length 32.3
  IN1 w0.254: v2(199.96,44.86) 199.96,45.06 199.23,45.78 195.23,45.78 192.62,43.16 186.5,43.16 186.06,42.73 180.28,42.73 177.2,45.81 177.2,49.97 v2(177.33,50.1)
  BOTTOM w0.254: v2(177.33,50.1) 177.33,50.05 177.01,49.73 PRB01.3 ; PRB41.1 200.07,44.98 v2(199.96,44.86)
N28714743: length 4.4
  TOP w0.102: PQB03.2 183.2,66.12 183.38,66.3 183.89,66.3 184.04,66.15 v1(184.35,66.15)
  TOP w0.254: PQB03.2 183.56,65.78 184.36,64.98 PRB43.1 183.8,64.52 PRB03.2
N28714752: length 23
  TOP w0.254: v2(202.22,57.68) 201.96,57.93 201.96,58.32 201.55,58.73 v1(197.09,58.73) 191.52,58.73 187.87,55.09 185.42,55.09 185.2,55.3 185.2,55.94 185.56,56.29 PRB02.2
  BOTTOM w0.254: PRB05.1 201.96,56.4 201.96,57.42 v2(202.22,57.68)
N28714753: length 22.9
  TOP w0.254: v2(201.33,57.68) 201.58,57.93 201.58,58.16 201.42,58.33 v1(198.57,58.33) 191.65,58.33 188.03,54.71 185.26,54.71 184.82,55.15 184.82,56 184.53,56.29 PRB02.3
  BOTTOM w0.254: PRB06.1 201.58,56.4 201.58,57.42 v2(201.33,57.68)
N28714782: length 1.7
  TOP w0.102: PRB22.2 v1(184.81,46.73)
N28714793: length 2.4
  TOP w0.102: v2(179.29,52.76) v1(178.71,52.76)
  TOP w0.508: v2(179.29,52.76) PCB14.1 179.98,53.83 179.99,53.84
N28810503: length 4.2
  TOP w0.102: CZ10.1 127.9,132.98 127.34,132.42 127.34,131.2 v1(127.69,130.84)
  TOP w0.127: UZ3.12 127.37,134.07 127.44,134 127.44,133.48 CZ10.1
N28810563: length 4.2
  TOP w0.102: v1(126.22,130.87) 126.88,131.53 126.88,132.54 CZ11.1
  TOP w0.127: CZ11.1 126.48,133.1 126.48,133.91 126.57,134.01 UZ3.10
N28856399: length 5.1
  BOTTOM w0.076: TP19.1 112.3,102.92 113.21,102.01 113.44,102.01 114.72,100.74 114.72,99.88 114.55,99.71 UC1.BA70
N28856402: length 8.4
  BOTTOM w0.076: UC1.BA68 114.41,98.94 114.27,98.8 113.62,98.8 113.3,99.11 113.3,101.23 111.92,102.61 110.41,102.61 TP20.1
N28857231: length 6.7
  BOTTOM w0.076: UC1.BB68 113.72,98.46 113.14,99.04 113.14,101.08 111.87,102.34 TP21.1
N28857234: length 6.4
  BOTTOM w0.076: TP22.1 111.5,103.34 111.65,103.34 113.47,101.52 113.47,99.48 113.84,99.11 UC1.BB69
N28857237: length 1
  TOP w0.102: v2(121.64,66.51) 121.98,66.86 TP23.1
  BOTTOM w0.076: v2(121.64,66.51) 121.58,66.51 UC1.AK13
N28857240: length 1.5
  TOP w0.102: TP24.1 121.65,65.21 121.62,65.24 v2(121.62,65.9)
  BOTTOM w0.076: UC1.AK12 121.31,66.22 v2(121.62,65.9)
N28861827: length 8
  BOTTOM w0.076: UC1.C64 135.72,95.89 135.86,96.04 137.02,96.04 137.71,96.73 138.26,96.73 138.67,97.14 138.67,97.31 138.94,97.58 139.33,97.98 141.97,97.98 RC138.1
N28938912: length 2.4
  BOTTOM w0.102: CC2.2 117.26,43.59 117.62,43.23 RC21.1 117.36,42.65 v1(116.62,42.65)
N29708599: length 5.9
  BOTTOM w0.076: TP25.1 116.7,57.13 116.7,58.75 117.4,59.45 117.4,61.88 UC1.AU5
N29708601: length 1.2
  TOP w0.102: v2(117.24,62.71) 117.57,62.38 TP26.1
  BOTTOM w0.076: v2(117.24,62.71) 117.68,62.27 UC1.AT5
N32842463: length 3.3
  TOP w0.102: RC137.2 125.61,66.02 125.96,65.67 v1(126.31,65.67) 126.77,65.67 v2(126.98,65.88)
  BOTTOM w0.076: UC1.U12 127.32,66.22 v2(126.98,65.88) 127.28,65.57 UC1.U11
N33188643: length 4.8
  TOP w0.203: RA23.2 RA24.1 32.55,22.16 v1(32.29,21.9) CA31.1
N36085760: length 2.5
  TOP w0.102: PD3.1 90.61,142.72 v1(90.29,142.4)
  TOP w0.254: PR7.2 89.62,143.29 PD3.1
N36085833: length 8.1
  TOP w0.254: PQ1.2 85.19,146.3 85.76,145.73 85.76,144.64 85.49,144.37 v1(85.49,144.14) 85.49,143.94 86.23,143.2 PQ2.1 87.65,143.2 87.92,142.93 PR7.1 88.35,143.37 88.93,143.95 PR4.2
N40598435: length 2.2
  BOTTOM w0.102: v1(102.53,136.01) PC307.1
  BOTTOM w0.508: PC307.1 103.59,136.09 PR301.2
N40598500: length 1.9
  BOTTOM w0.508: PC507.1 154.21,134.92 v2(154.21,135.45) 154.47,135.71 PR501.2
N40598503: length 1.9
  BOTTOM w0.102: PC315.2 v1(114.01,139.39)
  BOTTOM w0.254: PR306.1 PC315.2
N40598539: length 1.9
  BOTTOM w0.102: v1(164.19,138.28) 164.16,138.31 PC517.2
  BOTTOM w0.254: PR509.1 PC517.2
N40598619: length 2.2
  BOTTOM w0.102: v1(116.19,144.24) PR507.2
  BOTTOM w0.254: PD501.1 116.19,142.06 PR507.2
N41321201: length 3.8
  TOP w0.102: v1(205.14,45.3) 205.05,45.39 205.05,46.66 PCB28.1
  TOP w0.254: PCB28.1 204.57,47.81 PRB31.2 204.78,48.02 PQB06.2
N45784517: length 6.1
  BOTTOM w0.102: PCZ02.1 158.98,115.6 v1(159.47,116.09)
  BOTTOM w0.203: PUZ01.41 154.56,115.7 154.91,116.06 155.41,116.06 PCZ08.1
  BOTTOM w0.254: PCZ02.1 PRZ06.2 PCZ09.1 PCZ08.1
N45784764: length 2.4
  BOTTOM w0.203: PUZ01.38 154.31,116.9 v1(154.92,117.51) 155.18,117.77 PRZ16.2
N45784907: length 5.8
  TOP w0.203: PCZ33.1 150.13,118.74 149.96,118.9 149.96,118.9 149.78,119.08 149.78,119.08 149.51,119.35 v2(149.51,119.36) 149.51,119.66 PCZ26.2
  BOTTOM w0.102: PCZ27.2 149.12,120.85 v1(149.23,120.96)
  BOTTOM w0.203: PUZ01.28 149.81,119 149.51,119.29 v2(149.51,119.36) 149.51,119.64 PCZ27.2 148.3,120.03 PRZ51.2
N45784946: length 2.3
  TOP w0.102: v1(158.63,114.16) 158.35,114.16 157.64,114.87 PRZ01.1
  TOP w0.254: PCZ01.2 157.63,114.98 PRZ01.1
N45784991: length 1.9
  BOTTOM w0.102: PRZ20.2 154.28,107.04 v1(154.39,106.93)
  BOTTOM w0.254: PCZ13.1 PRZ20.2
N45785219: length 1.9
  TOP w0.102: PCZ35.1 144.62,117.64 143.87,117.64 v1(143.77,117.74)
  TOP w0.254: PRZ61.2 PCZ35.1
N45789065: length 1.5
  TOP w0.102: v1(158.42,78.06) 158.25,77.88 PCI12.1
N47599587: length 1.9
  TOP w0.102: v1(153.42,106.89) 153.42,107.88 PRZ24.2
  TOP w0.254: PCZ16.1 PRZ24.2
N47697054: length 3.4
  TOP w0.102: v1(170.6,51.58) 170.29,51.89 PRH05.2
  TOP w0.254: v2(169.58,52.7) PRH05.2
  BOTTOM w0.254: v2(169.58,52.7) 169.58,52.75 168.74,53.59 PUH01.7
N47701287: length 2.9
  BOTTOM w0.254: PUH01.11 v1(166.94,52.74) 166.94,52.2 166.79,52.05 PCH11.1 PRH11.2
N47701297: length 2.8
  TOP w0.102: v2(167.99,52.94) v1(167.99,53.5)
  TOP w0.254: v2(167.99,52.94) 168.63,52.3 PCH10.1
  BOTTOM w0.254: v2(167.99,52.94) 167.84,53.09 PUH01.9
N47710281: length 4.8
  BOTTOM w0.102: v1(48.78,29.4) 49.41,28.77 PC2504.1
  BOTTOM w0.254: PC2504.1 PR2504.2 50.98,29.69 51.15,29.52 PU2501.4
N47714748: length 1.8
  TOP w0.102: PRM01.2 v1(89.38,136.58)
N47719295: length 1.1
  TOP w0.102: PRM05.1 v1(92.72,132.65)
  vias: v2(90.93,132.6)
N47772279: length 2
  TOP w0.102: v1(148.13,123.29) PRZ55.1
  TOP w0.254: PCZ31.2 148.12,122.16 PRZ55.1
N47887852: length 1.9
  TOP w0.102: PR1804.2 v1(160.36,45.51)
N48572179: length 2.1
  BOTTOM w0.102: PCH14.2 171.66,50.1 v1(171.94,50.38)
  BOTTOM w0.254: PCH14.2 171.05,50.31 PRH12.1
N124752685: length 1.9
  TOP w0.102: RD11.1 v1(66.74,70.44)
  TOP w0.508: CD30.2 RD11.1
N124753277: length 1.9
  TOP w0.102: v1(56.65,69.65) 56.79,69.79 RD22.1
  TOP w0.305: CD59.2 RD22.1
N260603521: length 66.5
  TOP w0.102: v1(157.26,116.8) 157.16,116.8 v2(156.83,117.12)
  TOP w0.254: PRZ10.1 156.76,117.19 v2(156.83,117.12)
  IN1 w0.254: v2(159.23,65.8) 160.26,65.8 160.44,65.97 160.44,68.29 161.23,69.08 166.69,69.08 169.2,71.59 169.2,100.73 159.55,110.38 159.55,114.31 156.83,117.02 v2(156.83,117.12)
  BOTTOM w0.254: v2(159.23,65.8) 158.79,66.24 PHZ01.2

## Copper pours and planes (outline as drawn)
2.5V_VIN on BOTTOM (solid shape): 52.8,29.14 52.8,27.17 52.68,27.05 52.68,25.78 52.47,25.57 49.52,25.57 49.52,26.75 49.82,27.05 51.6,27.05 52.04,27.49 52.04,29.14 52.23,29.33 52.61,29.33
3V_SN on TOP (solid shape): 107.54,137.54 105.89,137.54 105.89,138.55 106.65,139.31 106.65,139.63 107.54,139.63
3V_VIN on TOP (solid shape): 105.32,142.17 105.32,140.77 105.06,140.52 104.05,140.52 103.86,140.71 103.86,142.17 103.92,142.24 105.25,142.24
3V_VIN on BOTTOM (solid shape): 106.33,142.49 106.33,141.98 106.14,141.79 106.14,141.03 106.84,140.33 106.84,138.87 106.78,138.81 105.87,138.81 105.78,138.89 104.96,138.89 103.34,137.27 101.94,137.27 101.94,139.44 101.87,139.51 101.87,139.92 101.31,139.92 101.31,140.11 101.87,140.11 101.87,140.69 101.06,141.5 101.06,142.17 101.13,142.24 105.38,142.24 105.7,142.55 106.27,142.55
5V_SN on TOP (solid shape): 157.01,138.11 157.01,137.22 157.13,137.09 157.64,137.09 157.77,136.96 157.77,136.08 157.64,135.95 156.12,135.95 155.99,136.08 155.99,138.11 156.12,138.23 156.88,138.23
5V_VIN on TOP (solid shape): 153.9,141.74 153.9,139.63 154.15,139.38 155.36,139.38 155.67,139.06 155.67,137.79 155.61,137.73 149.04,137.73 147.71,139.06 147.71,141.26 148,141.55 151.03,141.55 151.27,141.79 153.85,141.79
5V_VIN on BOTTOM: 150.97,139.25 150.97,142.64 151.04,142.71 153.02,142.71 153.07,142.65 153.07,139.31 153.2,139.19 154.09,139.19 154.28,139.38 156.56,139.38 157.13,138.81 157.13,137.35 157.07,137.28 156.12,137.28 155.67,137.73 153.93,137.73 153.49,137.28 152.94,137.28
+0.6V_DDR_VTT on TOP (solid shape): 56.52,51.62 56.58,51.55 56.58,48.06 56.77,47.87 56.77,47.3 56.96,47.11 57.91,47.11 57.91,46.09 56.45,46.09 55.12,47.42 55.12,50.92 54.99,51.04 54.99,52.89 56.52,52.89
+0.6V_DDR_VTT on TOP (solid shape): 69.09,47.62 69.09,46.85 69.38,46.56 72.75,46.56 73.03,46.28 73.03,45.84 72.71,45.52 70.39,45.52 70.23,45.37 70.23,44.95 69.34,44.95 69.34,45.2 68.07,46.47 68.07,47.74 68.2,47.87 68.84,47.87
+0.6V_DDR_VTT on TOP: 98.82,131.52 98.2,131.52 98.07,131.39 98.07,129.63 98.16,129.54 99.84,129.54 99.97,129.68 99.97,131.33 99.78,131.52 98.83,131.52
+0.6VSP on TOP (solid shape): 100.24,134.42 100.24,132.77 99.73,132.27 99.73,131.82 99.6,131.69 99.22,131.69 99.22,132.27 98.71,132.27 98.71,131.69 98.27,131.69 98.08,131.88 98.08,134.55 98.21,134.68 99.98,134.68
+0.6VSP on BOTTOM (solid shape): 98.13,134.81 100.05,134.81 100.24,134.62 100.24,133.28 100.16,133.21 99.02,133.21 98.98,133.17 98.32,133.17 98.22,133.07 96.24,133.07 96.2,133.1 96.2,133.24 96.24,133.28 97.7,133.28 97.82,133.41 97.82,133.79 97.6,134.02 97.21,134.02 97.07,133.88 95.84,133.88 95.79,133.93 95.79,134.72 95.86,134.78 96.67,134.78 96.83,134.95 97.99,134.95
+1.0V_AMPHYPLL on TOP: 130.75,67.46 131,67.46 131.51,66.96 134.43,66.96 135.07,66.32 135.07,65.72 134.84,65.49 133.92,65.49 133.61,65.81 131.8,65.81 131.48,66.13 131.48,66.35 130.65,67.18 130.65,67.37
+1.0V_MPHYGT on IN1 (solid shape): 129.49,68.68 129.49,68.48 129.68,68.29 130.19,68.29 130.39,68.1 130.39,67.06 130.31,66.98 128.22,66.98 128.07,67.13 128.07,67.81 128.71,68.45 128.71,68.83 128.82,68.94 129.22,68.94
+1.0V_MPHYGT on TOP: outline of 83 points within 128.08,57.77 140.15,68.92
+1.0V_MPHYGT on BOTTOM: 129.5,69.16 129.02,69.16 128.43,68.58 128.43,67.97 128,67.54 128,67.21 128.15,67.05 130.01,67.05 130.13,67.18 130.13,67.51 129.96,67.69 129.96,67.75 130.08,67.88 130.08,68.07 129.89,68.26 129.7,68.26 129.58,68.38 129.58,69.09
+1.0V_MPHYGT on BOTTOM: 139.03,57.39 138.92,57.41 138.21,58.12 138.21,58.61 138.69,59.09 140.41,59.09 140.69,58.81 142.2,58.81 142.21,58.81 142.68,58.81 142.68,58.81 144.21,58.81 144.44,58.57 148.02,58.57 148.27,58.32 148.27,57.1 148.02,56.86 139.47,56.86 139.38,56.96 139.32,57.2 139.12,57.33
+1.0V_PRIM on TOP (solid shape): 149.01,76.46 149.01,74.04 148.88,73.91 148.12,73.91 147.93,74.1 147.93,74.48 147.84,74.57 146.93,74.57 146.78,74.42 146.02,74.42 146,74.44 146,75.18 146.03,75.21 147.3,75.21 147.3,75.22 147.56,75.47 147.56,75.47 147.84,75.76 147.84,76.78 147.93,76.87 148.6,76.87
+1.0V_PRIM on BOTTOM (solid shape): 149.86,63.61 149.86,60.69 149.16,60 149.16,59.19 149.08,59.11 147.26,59.11 147.09,59.28 147.09,60.61 146.88,60.82 145.86,60.82 145.86,61.71 147.96,61.71 148.21,61.96 148.21,63.55 148.22,63.56 148.22,64 148.4,64.19 149.28,64.19
+1.0V_PRIM on BOTTOM (solid shape): outline of 126 points within 145.41,67.35 150.18,74.43
+1.0V_PRIM on IN1 (solid shape): 149.74,69.56 149.74,67.46 152.02,65.18 152.02,62.07 151.58,61.62 148.53,61.62 148.27,61.88 148.27,64.1 148.41,64.24 148.78,64.24 148.97,64.43 148.97,64.73 148.59,65.11 148.59,69.56 148.85,69.81 149.48,69.81
+1.0V_PRIM on TOP: outline of 128 points within 121.1,56.7 157.2,72.48
+1.0V_PRIM on VCC: 120.94,58.99 120.94,70.42 129.98,70.42 132.39,68 147.5,68 151.57,63.94 155.1,63.94 155.1,60.51 132.77,60.51 131.25,58.99
+1.0V_VCCST on TOP (solid shape): 144.39,71.1 144.39,69.83 144.53,69.69 146.1,69.69 146.43,70.02 147,70.02 147,69.13 146.57,69.13 146.31,68.86 145.67,68.86 145.48,68.67 145.48,67.92 145.47,67.91 145.26,67.91 145.26,68.21 144.72,68.21 144.72,67.65 144.46,67.65 144.34,67.78 144.34,68.4 143.36,69.38 143.36,71.02 143.51,71.17 144.31,71.17
+1.0V_VCCST on BOTTOM (solid shape): outline of 82 points within 135.49,68.57 137.64,69.97
+1.0V_VCCST on TOP: 131.84,71.14 131.84,70.83 132.03,70.64 134.5,70.64 134.57,70.7 135.14,70.7 135.14,70.19 131.77,70.19 131.39,70.57 131.39,71.14 131.47,71.22 131.76,71.22
+1.0V_VCCST_C on TOP (solid shape): 146,67.33 145.99,67.16 146.05,67 146.05,66.89 146.31,66.64 147.39,66.64 147.45,66.57 147.45,65.94 147.39,65.88 145.16,65.88 145.1,65.94 145.1,66.38 144.53,66.96 144.53,67.46 145.86,67.46
+1.0V_VCCSTG on TOP (solid shape): 145.93,60.67 146.31,60.67 146.5,60.48 146.5,58.89 147.7,57.68 147.7,56.42 147.58,56.3 147.58,54.76 147.45,54.64 145.93,54.64 145.93,56.73 145.16,57.49 145.16,60.8 145.35,60.99 145.61,60.99
+1.0VS_VCCIO on TOP: 133.67,42.76 133.07,42.76 129.7,46.13 126.11,46.13 125.45,46.79 124.3,46.79 116.96,54.14 116.96,58.66 117.1,58.8 119.41,58.8 119.86,58.35 119.86,54.14 120.62,53.38 121.15,53.38 123.99,50.54 128.05,50.54 128.05,50.54 130.21,50.54 136.05,56.38 139.08,56.38 139.3,56.6 141.42,56.6 141.8,56.99 145.48,56.99 145.73,56.73 145.73,56.31 145.22,56.31 145.22,55.8 145.73,55.8 145.73,55.51 145.22,55.51 145.22,55 145.73,55 145.73,54.57 144.72,53.56 144.72,50.88 144.72,49 144.72,44.54 142.94,42.76 ; 1 cut-out
+1.0VS_VCCIO on TOP: 120.86,85.56 120.25,85.56 119.64,84.95 119.64,83.83 120.4,83.07 120.4,82.54 120.86,82.08 120.88,82.08 121.39,82.59 121.59,82.59 121.72,82.72 121.72,82.94 121.59,83.07 120.98,83.07 120.88,83.17 120.88,83.76 120.83,83.81 120.35,83.81 120.17,83.99 120.17,84.72 120.5,85.05 120.86,85.05
+1.0VS_VCCIO on TOP: 119.81,77.59 120.25,77.59 120.32,77.51 120.32,77.28 120.58,77.03 121.74,77.03 121.92,76.85 121.92,76.01 121.8,75.88 121.59,75.88 121.26,75.55 121.22,75.55 121.13,75.46 119.76,75.46 119.74,75.49 119.74,75.95 119.83,76.04 120.08,76.04 120.21,76.16 120.21,76.81 119.92,77.1 119.81,77.1 119.71,77.2 119.71,77.48
+1.0VS_VCCIO on BOTTOM: 120.87,75.77 120.86,75.77 120.76,75.79 120.65,75.77 120.64,75.77 120.27,75.77 119.87,76.16 119.85,76.19 119.82,76.21 119.71,76.32 119.71,76.65 119.74,76.67 119.86,76.8 119.86,76.98 119.81,77.05 119.71,77.13 119.71,77.45 119.84,77.58 120.05,77.58 120.47,77.16 120.47,77.16 120.59,77.16 120.72,77.1 120.86,77.12 120.87,77.12 121.16,77.12 121.5,77.04 121.71,77.31 121.72,77.33 121.81,77.42 122.13,77.42 122.39,77.16 122.39,76.09 122.13,75.84 121.62,75.84 121.61,75.84 121.4,75.86 121.22,75.77
+1.0VS_VCCIO on VCC: 115.33,57.08 114.97,57.44 114.97,76.53 115.96,77.53 121.21,77.53 122.08,76.66 122.08,75.98 120.43,74.33 120.43,58.84 118.67,57.08
+1.0VS_VCCIO on IN2: 119.95,75.72 119.83,75.85 119.83,76.48 119.64,76.67 119.64,83.97 119.76,84.1 120.33,84.1 121.16,83.27 122.18,83.27 122.49,82.96 122.49,75.97 122.24,75.72
+1.2V_DDR on BOTTOM (solid shape): 86.01,128.58 88.05,128.58 88.05,129.15 89.32,129.15 89.63,128.84 89.63,127.82 90.2,127.25 90.2,118.8 88.93,117.53 80.04,117.53 79.66,117.91 79.66,118.75 83.75,122.84 83.75,123.35 83.79,123.39 83.79,128.9 84.04,129.15 86.01,129.15
+1.2V_DDR on BOTTOM (solid shape): 57.25,84.97 57.33,84.79 57.53,84.71 58.97,84.71 59.07,84.73 59.16,84.78 59.18,84.78 59.23,84.73 59.82,84.73 59.99,84.91 60.02,84.9 60.18,84.93 60.32,85.02 60.54,85.02 60.62,84.96 60.72,84.91 60.79,84.84 60.76,84.74 60.22,84.2 59.16,84.2 59.07,84.25 58.97,84.27 57.53,84.27 57.35,84.21 57.25,84.04 57.19,83.97 57.1,83.98 56.86,84.04 56.65,83.94 56.54,83.91 56.47,84.01 56.47,84.34 57.16,85.02 57.24,85.02
+1.2V_DDR on BOTTOM (solid shape): outline of 84 points within 56.47,78.97 61.79,83.45
+1.2V_DDR on BOTTOM (solid shape): outline of 5015 points within 56.47,68.99 81.34,85.02
+1.2V_DDR on IN1: outline of 922 points within 56.55,43.11 122.72,119.06
+1.2VP on TOP (solid shape): 97.06,135.38 97.06,134.49 97,134.42 96.3,134.42 95.6,135.12 95.6,135.44 96.05,135.89 96.55,135.89
+1.2VP on TOP (solid shape): 88.05,132.46 88.05,130.17 87.54,129.66 83.73,129.66 83.6,129.79 83.6,132.33 83.98,132.71 87.79,132.71
+1.2VP on BOTTOM (solid shape): 88.05,135.06 88.05,131 88.93,130.11 88.93,129.6 88.68,129.34 83.98,129.34 83.6,129.73 83.6,135.06 84.11,135.57 87.54,135.57
+1.2VP on BOTTOM (solid shape): 96.76,135.92 96.76,135.09 96.58,134.91 95.79,134.91 95.6,134.72 95.6,133.92 95.56,133.88 95.42,133.88 95.39,133.92 95.39,134.76 95.33,134.81 95.33,135.29 96.11,136.06 96.62,136.06
+1.8V_EMMC on TOP (solid shape): 138.56,40.3 138.56,34.91 138.48,34.84 137.9,34.84 137.82,34.91 137.82,40.15 138,40.32 138.53,40.32
+1.8V_PRIM on IN1 (solid shape): 59.83,41.4 59.83,41.32 59.36,40.86 58.86,40.86 57.84,41.87 57.84,42.45 58.22,42.83 58.41,42.83
+1.8V_PRIM on IN1 (solid shape): 127.21,54.06 127.22,54.06 128.18,53.11 128.18,51.49 127.35,50.67 126.53,50.67 125.73,51.46 125.73,52.04 125.76,52.05 125.99,52.38 125.76,52.72 125.73,52.73 125.73,53.75 125.43,54.05 125.43,54.35 126.09,55.01 126.26,55.01
+1.8V_PRIM on IN1 (solid shape): 140.06,53.78 141.39,53.78 141.7,53.46 141.7,51.56 141.51,51.37 139.94,51.37 139.87,51.43 138.74,52.36 137.3,52.67 137.22,52.7 137.19,52.77 137.19,54.48 137.45,54.73 139.11,54.73
+1.8V_PRIM on TOP: 58.93,41.65 59.12,41.84 59.12,42.6 58.87,42.86 57.31,42.86 56.99,42.54 56.99,41.84 57.18,41.65
+1.8V_PRIM on TOP: outline of 87 points within 121.26,52.51 128.05,68.29
+1.8V_PRIM on TOP: 103.98,54.99 102.9,54.99 102.52,54.61 102.52,53.46 102.65,53.34 103.98,53.34 104.11,53.46 104.11,54.86
+1.8V_PRIM on TOP: 43.79,49.78 42.52,49.78 42.33,49.97 42.33,50.8 42.58,51.05 43.53,51.05 44.04,50.54 44.04,50.03
+1.8V_PRIM on BOTTOM: 140.34,53.04 141.31,53.04 145.02,49.34 145.13,48.75 145.63,49.08 152.62,49.08 153.13,48.57 153.13,47.3 152.61,47.3 152.61,46.8 153.13,46.8 153.13,46.5 152.61,46.5 152.61,46 153.13,46 153.13,45.4 153.07,45.33 151.74,45.33 151.74,45.34 149.52,45.34 149.01,45.85 145,45.85 141.64,49.2 141.64,49.21 141.54,50.36 141.14,51.43 141.13,51.44 141.13,51.67 140.64,52.16 140.57,52.24 140.51,52.31 140.43,52.39 140.43,52.44 140.19,52.68 140.19,52.9
+1.8V_PRIM on IN1: 102.46,53.65 102.46,51.81 102.65,51.62 103.86,51.62 104.11,51.87 104.11,53.84 103.92,54.03 102.84,54.03
+1.8V_PRIM on IN1: 41.88,50.92 41.88,49.97 42.13,49.72 43.28,49.72 43.4,49.84 43.4,50.67 43.02,51.05 42.01,51.05
+1.8VALWP on TOP (solid shape): 155.8,48.05 155.8,47.03 155.67,46.9 154.78,46.9 154.66,47.03 154.66,48.05 154.78,48.17 155.67,48.17
+1.8VALWP on BOTTOM (solid shape): 158.72,48.11 158.72,45.38 153.45,45.38 153.32,45.51 153.32,47.92 153.58,48.17 158.66,48.17
+1VALWP on TOP (solid shape): 156.18,56.19 156.18,53.72 155.74,53.27 152.82,53.27 152.5,53.59 152.5,56.26 152.69,56.45 155.93,56.45
+1VALWP on BOTTOM (solid shape): 158.34,56.62 158.34,52.75 158.15,52.56 153.01,52.56 152.94,52.62 152.94,56.94 158.02,56.94
+2.5V_MEM on TOP (solid shape): 68.91,45.32 68.91,44.88 68.79,44.76 65.48,44.76 65.41,44.83 65.41,46.13 65.71,46.43 67.79,46.43
+2.5V_MEM on TOP (solid shape): 83.41,46.47 83.41,45.33 83.28,45.2 82.58,45.2 81.43,44.06 80.1,44.06 79.73,44.43 79.73,45.36 79.14,45.95 79.14,46.53 79.2,46.59 83.29,46.59
+2.5V_MEM on TOP (solid shape): 53.81,38.95 53.81,37.95 53.37,37.5 52.88,37.5 52.85,37.48 52.85,36.99 52.83,36.96 52.64,36.96 52.62,36.98 52.62,37.48 52.6,37.5 51.74,37.5 51.64,37.6 51.64,38.74 52.09,39.19 53.58,39.19
+2.5V_MEM on BOTTOM (solid shape): 81.54,46.15 81.54,45.33 81.47,45.27 78.73,45.27 78.66,45.3 78.59,45.32 78.26,45.65 78.26,46.31 78.34,46.38 81.31,46.38
+2.5V_MEM on BOTTOM (solid shape): 68.33,46.22 68.33,45.65 68.2,45.52 67.44,45.52 67.38,45.58 65.66,45.58 65.53,45.71 65.53,46.28 65.66,46.41 67.44,46.41 67.5,46.47 68.07,46.47
+2.5VP on TOP (solid shape): 52.5,37.34 52.5,36.84 52.52,36.82 52.97,36.82 52.98,36.84 52.98,37.35 53.01,37.37 53.76,37.37 53.92,37.21 53.92,35.51 53.75,35.34 51.83,35.34 51.7,35.46 51.7,37.29 51.79,37.37 52.46,37.37
+2.5VP on BOTTOM (solid shape): 54.04,37.18 54.04,34.88 53.79,34.63 53.02,34.63 52.77,34.38 52.77,32.67 52.64,32.54 52.14,32.54 52.01,32.67 52.01,34.34 51.16,35.18 51.16,37.05 51.42,37.3 53.92,37.3
+3.3V_WLAN on TOP (solid shape): 71.5,139.99 71.5,137.3 71.21,137.01 69.38,137.01 68.98,137.41 68.98,139.99 69.27,140.28 71.21,140.28
+3.3V_WLAN on TOP (solid shape): 70.39,124.26 70.39,120.58 70.01,120.2 67.98,120.2 67.6,120.58 67.6,122.61 67.22,122.99 67.22,124.01 67.34,124.14 68.61,124.14 69,124.52 70.14,124.52
+3.3V_WLAN on BOTTOM (solid shape): 72.31,140.5 72.31,139.19 72.2,139.08 70.16,139.08 68.15,137.07 68.15,124.02 69.72,122.45 72.23,122.45 72.28,122.4 72.28,120.53 71.54,119.8 69.23,119.8 66.06,122.97 66.06,137.83 68.7,140.47 68.71,140.47 68.84,140.6 72.2,140.6
+3V_DVDD on TOP (solid shape): 35.09,9.33 35.59,9.33 35.72,9.2 37.94,9.2 38.13,9.01 38.13,8.69 37.94,8.5 35.59,8.5 35.47,8.63 34.71,8.63 34.58,8.76 34.58,9.14 32.86,10.85 32.42,10.85 32.36,10.92 32.36,11.11 32.42,11.17 33.24,11.17
+3V_DVDD on TOP (solid shape): 35.61,19.84 35.61,17.51 35.47,17.37 35.47,15.71 35.33,15.58 34.81,15.58 34.76,15.52 34.76,15.04 34.6,14.89 34.6,14.41 34.33,14.13 32.46,14.13 32.38,14.21 32.38,14.31 32.48,14.41 33.5,14.41 34.01,14.92 34.01,17.2 34.58,17.78 34.58,18.52 34.45,18.64 33.83,18.64 33.78,18.69 33.78,19.88 33.97,20.07 35.38,20.07
+3VALW on TOP (solid shape): 46.87,91.15 46.87,90.23 46.48,89.85 45.28,89.85 44.9,90.23 44.9,91.15 45.09,91.34 46.67,91.34
+3VALW on TOP (solid shape): 54.49,67.15 54.49,65.81 54.23,65.56 53.28,65.56 53.22,65.62 53.22,67.27 53.28,67.34 54.29,67.34
+3VALW on TOP (solid shape): 69.88,126.04 69.88,124.9 69.63,124.65 67.22,124.65 67.22,125.92 67.47,126.17 69.76,126.17
+3VALW on TOP (solid shape): 30.16,71.02 30.16,69.37 30.1,69.3 28.71,69.3 28.2,69.82 28.2,70.7 28.92,70.7 29.3,71.09 30.1,71.09
+3VALW on TOP (solid shape): 36.74,57.7 36.74,55.94 36.36,55.56 34.58,55.56 34.42,55.71 34.42,57.69 34.6,57.86 36.58,57.86
+3VALW on TOP (solid shape): 25.43,102.87 25.43,99.56 24.99,99.12 22.2,99.12 22.07,99.25 22.07,100.13 22.7,100.77 22.7,102.04 23.66,102.99 25.31,102.99
+3VALW on TOP (solid shape): 54.61,73.62 54.61,70.96 54.42,70.77 53.47,70.77 53.47,71.27 53.53,71.34 53.53,71.84 53.28,72.1 53.28,73.75 53.34,73.81 54.42,73.81
+3VALW on TOP (solid shape): 99.03,57.59 99.03,56.51 98.84,56.32 98.46,56.32 98.21,56.07 97.32,56.07 97.25,56.13 97.25,56.7 97.32,56.76 98.33,56.76 98.52,56.95 98.52,57.53 98.65,57.65 98.97,57.65
+3VALW on TOP (solid shape): 147.48,102.1 147.48,100.01 147.16,99.69 146.72,99.69 146.59,99.82 146.59,100.77 146.47,100.9 145.83,100.9 145.7,101.02 145.7,103.18 145.77,103.25 146.34,103.25
+3VALW on TOP (solid shape): 170.77,45.51 171.28,45.51 171.28,46.08 171.66,46.08 171.79,45.95 171.79,43.94 171.53,43.68 169.52,43.68 169.33,43.87 169.33,45.01 170.39,46.08 170.77,46.08
+3VALW on TOP (solid shape): 53.6,82 53.6,80.67 52.9,79.97 52.9,79.91 52.77,79.78 52.33,79.78 52.26,79.85 52.26,81.56 52.07,81.75 50.87,81.75 50.23,81.12 50.23,80.35 49.66,79.78 49.09,79.78 48.9,79.97 48.9,81.75 49.34,82.2 53.41,82.2
+3VALW on TOP (solid shape): 119.24,138.96 119.24,138.92 119.28,138.87 119.28,137.79 120,137.07 120.91,137.07 121.14,136.94 121.38,137.07 122.18,137.07 123.35,138.23 126.02,138.23 126.27,137.98 126.27,136.2 126.21,136.14 125.38,136.14 124.68,135.44 123.86,135.44 122.84,134.42 122.84,129.95 120.33,127.44 115.1,127.44 114.27,128.27 114.27,131 114.33,131.06 114.84,131.06 114.84,130.49 116.81,130.49 116.81,131.06 118.84,131.06 119.54,131.76 119.54,135.95 118.53,136.96 118.53,139.03 118.56,139.06 119.13,139.06
+3VALW on BOTTOM (solid shape): 26.7,99.94 26.7,99.25 26.58,99.12 24.48,99.12 24.29,99.31 24.29,99.88 24.61,100.2 26.45,100.2
+3VALW on BOTTOM (solid shape): 55.53,116.26 55.53,113.66 54.96,113.09 53.37,113.09 52.99,113.47 52.99,116.14 53.37,116.52 55.28,116.52
+3VALW on BOTTOM (solid shape): 59.47,126.04 59.47,123.5 59.09,123.12 57.18,123.12 56.93,123.38 56.93,125.79 57.44,126.3 59.22,126.3
+3VALW on BOTTOM (solid shape): 43.34,89.47 43.34,88.96 43.02,88.64 43.02,87.18 42.71,86.86 42.13,86.86 40.93,88.07 40.93,89.47 41.25,89.78 43.02,89.78
+3VALW on BOTTOM (solid shape): 49.31,36.25 49.31,35.17 49.25,35.1 48.23,35.1 48.17,35.17 48.17,36.25 48.29,36.37 49.18,36.37
+3VALW on BOTTOM (solid shape): 147.39,42.38 147.39,40.89 147.15,40.65 145.65,40.65 145.53,40.78 145.53,42.3 145.75,42.53 147.24,42.53
+3VALW on BOTTOM (solid shape): 149.13,51.24 149.13,50.67 148.94,50.48 146.02,50.48 145.64,50.86 145.64,51.18 145.83,51.37 149.01,51.37
+3VALW on BOTTOM (solid shape): 151.29,65.71 151.29,63.81 151.16,63.69 150.4,63.69 150.15,63.94 150.15,65.37 150.19,65.37 150.19,65.81 150.15,65.81 150.15,66.09 150.92,66.09
+3VALW on BOTTOM (solid shape): 171.91,45.3 171.91,44.39 171.27,43.75 169.45,43.75 169.26,43.94 169.26,44.19 170.46,45.38 171.83,45.38
+3VALW on BOTTOM (solid shape): 48.36,27.37 48.36,26.67 48.42,26.61 49.37,26.61 49.37,26.35 48.8,26.35 48.8,25.85 49.37,25.85 49.37,25.59 47.4,25.59 47.28,25.71 47.28,27.37 47.41,27.5 48.23,27.5
+3VALW on TOP: 148.07,51.32 148.13,51.39 148.13,55.28 147.93,55.49 147.93,56.07 149.35,56.07 149.46,55.97 149.46,55.31 149.74,55.03 149.74,53.91 149.1,53.28 149.1,44.1 148.18,43.18 148.18,41.84 147.93,41.59 146.27,41.59 146.02,41.84 146.02,44.25 146.69,44.92 146.69,48.76 145.64,49.81 145.64,51.11 145.85,51.32
+3VALW on VCC: 48.91,34.98 47.91,35.98 47.91,54.06 48.55,54.69 48.55,63.66 47.51,64.7 46.39,64.7 46.39,78.33 42.07,82.65 42.07,89.23 50.71,97.87 50.71,114.74 55.55,114.74 56.04,114.25 56.04,46.69 61.52,41.21 89.29,41.21 105.17,57.08 114.61,57.08 115.12,56.57 118.88,56.57 120.79,58.48 131.46,58.48 132.98,60 155.25,60 158.04,57.21 161.09,57.21 166.3,52 170.74,52 171.74,51.01 171.74,43.98 171.38,43.62 161.3,43.62 159.4,45.52 133.79,45.52 133.02,44.76 117.28,44.76 107.5,34.98 81.36,34.98 79.9,36.44 78.92,36.44 77.46,34.98
+3VALW on VCC: 121.83,119.42 119.01,122.23 88.15,122.23 86.75,123.63 78.12,123.63 76.97,124.77 56.8,124.77 56.8,128.22 57.42,128.84 109.61,128.84 111.65,130.87 121.83,130.87
+3VALW_EC on TOP (solid shape): 31.04,68.54 32.39,68.54 32.44,68.49 32.44,68.34 32.39,68.29 32.39,67.4 32.46,67.32 32.46,67.19 32.39,67.12 32.26,67.12 31.6,67.78 29.97,67.78 29.95,67.81 29.95,68.77 30.08,68.9 30.69,68.9
+3VALW_EC on IN1 (solid shape): 31.78,74.07 31.78,71.07 31.77,71.04 31.74,71.02 31.4,70.67 31.74,70.31 31.77,70.3 31.78,70.26 31.78,67.49 31.77,67.45 31.74,67.44 31.41,67.08 31.74,66.73 31.77,66.71 31.78,66.68 31.78,65.35 31.76,65.28 31.69,65.25 31.36,64.89 31.69,64.54 31.76,64.51 31.78,64.44 31.78,59.24 31.39,58.84 30.75,58.84 29.82,59.78 29.82,61.49 29.82,61.5 29.85,61.65 29.82,61.81 29.82,61.82 29.82,62.38 29.82,62.39 29.85,62.54 29.82,62.69 29.82,62.7 29.82,65.79 29.95,66.03 29.87,66.29 29.85,66.36 29.88,66.43 29.98,66.72 29.82,66.98 29.82,74.31 29.92,74.4 31.45,74.4
+3VALW_EC on TOP: 39.13,62.49 39.3,62.49 39.32,62.46 39.32,60.58 39.21,60.47 39.21,60.03 39.55,59.69 39.55,58.81 39.46,58.73 38.88,58.73 38.81,58.79 38.81,60.48 39.08,60.75 39.08,62.43
+3VALW_EC on BOTTOM: 110.42,30.89 110.42,29.35 110.56,29.21 112.25,29.21 112.34,29.29 112.34,30.86 112.07,31.12 110.65,31.12
+3VALW_PCH on BOTTOM (solid shape): 149.53,66.22 149.53,65.71 149.55,65.71 149.55,65.48 149.53,65.48 149.53,65.07 149.43,64.97 148.86,64.97 148.75,65.08 147.86,65.08 147.05,64.27 147.05,62.59 146.93,62.47 144.72,62.47 144.66,62.54 144.66,64.19 144.67,64.21 144.67,65.83 145.2,66.35 149.39,66.35
+3VALW_PCH on BOTTOM: 132.01,55.03 132.01,54.12 131.65,53.77 129.37,53.77 128.78,54.36 128.78,55.09 129.04,55.34 131.7,55.34
+3VALW_PCH on IN1: 128.54,61.17 128.19,61.44 127.85,61.17 127.84,61.13 123.65,61.13 123.63,61.16 123.36,61.39 123.03,61.26 122.95,61.23 122.88,61.26 121.81,62.33 121.78,62.42 121.84,62.49 122.01,62.98 121.51,63.13 121.41,63.12 121.36,63.21 121.36,63.39 121.1,63.64 121.1,64.7 120.68,64.7 119.92,65.46 118.02,65.46 117.64,65.84 117,65.84 117,66.61 118.14,67.75 120.54,67.75 121.05,68.26 121.05,69.77 121.8,70.51 121.8,71.65 122.75,72.61 126.56,72.61 127,72.16 127,70.15 126.24,69.39 126.12,69.26 126.12,67.31 126.25,67.18 128.87,64.56 130.38,64.56 131.83,66 131.83,66.64 132.21,67.02 133.71,67.02 134.01,67.32 134.71,67.32 136.13,68.74 140.3,68.74 142.22,66.82 144.53,66.82 146.43,64.91 146.43,62.45 146.18,62.19 143.87,62.19 141.62,64.44 136.77,64.44 133.46,61.13 128.55,61.13
+3VALWP on TOP (solid shape): 119.03,133.79 119.03,131.76 118.53,131.25 112.68,131.25 112.3,131.63 112.3,133.79 112.43,133.92 118.91,133.92
+3VALWP on BOTTOM (solid shape): 117.51,135.19 117.51,131.5 117,131 111.03,131 110.78,131.25 110.78,134.81 111.29,135.31 117.38,135.31
+3VLP on BOTTOM (solid shape): 109.38,137.85 110.78,137.85 110.91,137.98 111.67,137.98 111.69,137.96 111.69,136.99 111.67,136.96 108.75,136.96 108.24,137.47 108.24,138.23 108.3,138.3 108.94,138.3
+3VS on TOP (solid shape): 221.46,47.86 221.46,46.78 221.33,46.65 219.43,46.65 219.3,46.78 219.3,47.79 219.49,47.98 221.33,47.98
+3VS on TOP (solid shape): 75.09,124.52 75.09,123.63 73.82,122.36 71.28,122.36 70.77,122.87 70.77,125.41 70.9,125.53 74.08,125.53
+3VS on TOP (solid shape): 221.2,59.8 221.2,59.1 220.95,58.84 220.95,58.08 220.7,57.83 219.43,57.83 219.11,58.14 218.6,58.14 218.54,58.21 218.54,59.54 218.92,59.92 221.08,59.92
+3VS on TOP (solid shape): 63.56,47.01 63.56,46.46 63.61,46.41 64.7,46.41 65.22,45.9 65.22,44.9 64.48,44.16 64.48,42.98 64.04,42.54 61.64,42.54 61.45,42.72 59.91,42.72 58.59,44.04 57.27,44.04 56.17,45.14 56.17,45.46 56.42,45.71 57.47,45.71 58.16,45.71 58.44,45.99 58.57,45.99 59.13,45.43 59.13,44.87 59.31,44.69 59.98,44.69 60.14,44.54 60.14,44.14 60.43,43.85 61.6,43.85 62.16,43.3 62.73,43.3 63.12,43.68 63.12,44.25 63.15,44.46 63.12,44.68 63.12,46.13 62.84,46.41 62.84,46.99 62.89,47.04 63.53,47.04
+3VS on TOP (solid shape): outline of 88 points within 101.12,119.11 126.27,134.85
+3VS on BOTTOM (solid shape): 28.42,47.18 28.42,46.22 27.85,46.22 27.85,44.83 28.42,44.83 28.42,44.25 28.23,44.06 26.83,44.06 26.51,44.38 26.51,47.18 26.77,47.43 28.16,47.43
+3VS on TOP: 216.98,31.46 217.1,31.58 218.11,31.58 218.23,31.7 218.23,32.31 218.13,32.41 216.71,32.41 216.56,32.26 216.56,31.89 216.2,31.52 216.2,30.08 216.34,29.95 216.87,29.95 216.98,30.06
+3VS on VCC: 33.79,23.3 32.78,24.32 27.44,24.32 27.09,24.68 27.09,47.45 33.54,53.91 47.41,53.91 47.41,35.77 48.7,34.48 77.67,34.48 79.13,35.94 79.68,35.94 81.15,34.48 107.71,34.48 117.49,44.25 133.24,44.25 134,45.02 159.19,45.02 161.09,43.11 171.59,43.11 172.25,43.77 172.25,51.22 170.95,52.51 166.51,52.51 161.3,57.72 158.25,57.72 155.61,60.36 155.61,71.41 153.96,73.06 153.96,93.13 150.25,96.83 144.81,96.83 144.81,123.61 141.11,127.31 122.34,127.31 122.34,134.95 123.08,135.69 139.12,135.69 151.42,123.4 151.42,106.13 159.93,97.62 159.93,78.06 167.93,70.06 167.93,64.34 189.67,42.6 194.24,42.6 197.29,39.56 201.05,39.56 201.84,40.34 201.84,56.19 215.02,56.19 218.96,60.13 220.27,60.13 220.63,59.77 220.63,41.06 219.26,39.68 213.42,39.68 211.11,37.38 211.11,33.08 186.07,33.08 183.42,35.72 183.42,39.53 182.13,40.83 179.25,40.83 177.96,39.53 177.96,35.72 175.32,33.08 153.96,33.08 153.96,39.53 152.16,41.33 136.83,41.33 133.64,38.14 133.64,32.93 129.98,29.27 41.2,29.27 35.23,23.3 ; 1 cut-out
+3VS_SSD on TOP: 24.57,31.15 22.97,31.15 22.51,30.69 22.51,29.27 21.32,28.08 21.01,28.08 20.53,27.59 20.53,25.61 20.76,25.38 23.53,25.38 24.62,26.47 24.62,31.1
+3VS_SSD on TOP: 38.36,26.68 35.31,26.68 35.09,26.91 35.09,29.75 35.31,29.98 38.18,29.98 38.54,29.62 38.54,26.86
+3VS_SSD on BOTTOM: 34.97,27.35 34.78,27.54 31.8,27.54 31.73,27.57 31.7,27.64 31.43,27.97 31.04,27.8 30.39,27.8 30.13,27.54 22.52,27.54 22.27,27.28 22.27,25.82 22.14,25.7 21.06,25.7 20.93,25.83 20.93,29.08 22.05,30.2 29.82,30.2 29.85,30.18 34.12,30.18 34.59,29.71 37.7,29.71 39.33,31.35 41.1,31.35 42.2,32.44 42.2,34.73 37.94,38.98 35.98,38.98 31.59,43.37 29.12,43.37 28.61,43.87 28.61,46.67 28.99,47.05 33.88,47.05 44.99,35.94 44.99,27.85 42.71,25.57 40.98,25.57 40,24.6 35.21,24.6 34.97,24.84
+5V_AVDD on TOP (solid shape): 25.75,18.22 25.75,15.62 26.2,15.17 27.15,15.17 27.21,15.11 27.21,14.98 27.15,14.92 25.94,14.92 25.12,15.74 25.12,18.22 25.18,18.28 25.69,18.28
+5V_HDD on BOTTOM (solid shape): 181.01,37.59 182.34,37.59 182.34,38.15 186.91,38.15 186.98,38.08 186.98,36.81 186.79,36.62 186.09,36.62 185.84,36.36 185.84,35.22 185.26,34.65 182.1,34.65 181.6,35.16 179.38,35.16 178.66,35.87 178.66,37.52 179.29,38.16 181.01,38.16
+5V_HDMI on TOP (solid shape): 18.58,103.56 18.58,102.67 18.32,102.42 16.29,102.42 14.3,100.43 12.35,100.43 12.16,100.62 12.16,101.13 12.35,101.32 13.59,101.32 14.03,101.76 14.03,102.22 15.51,103.69 18.45,103.69
+5V_PVDD on TOP (solid shape): 29.31,10.6 29.31,8.53 28.72,7.95 28.46,7.95 28.37,8.03 28.37,8.23 29.07,8.92 29.07,10.6 29.12,10.65 29.26,10.65
+5V_PVDD on TOP (solid shape): 31.3,10.6 31.3,9.81 31.78,9.33 32.67,9.33 34.07,7.93 34.07,3.23 33.82,2.98 32.23,2.98 32.04,3.17 32.04,7.36 31.4,8 31.4,8.31 31.78,8.69 31.78,9.01 31.07,9.72 31.07,10.6 31.12,10.65 31.25,10.65
+5V_PVDD on BOTTOM (solid shape): 29.88,8.12 31.21,8.12 31.53,8.44 32.23,8.44 32.48,8.19 32.48,7.23 32.23,6.98 28.93,6.98 28.36,7.55 28.36,8.19 28.99,8.83 29.18,8.83
+5VALW on TOP (solid shape): 90.53,133.11 90.53,132.22 91.13,131.61 91.13,131.08 91,130.95 89.9,130.95 89.88,130.96 89.88,133.1 89.91,133.13 90.51,133.13
+5VALW on TOP (solid shape): 131.42,138.23 131.42,136.38 131.16,136.12 127.73,136.12 127.67,136.19 127.67,138.03 127.8,138.15 128.37,138.15 128.89,138.68 130.97,138.68
+5VALW on BOTTOM (solid shape): 24.55,42.79 24.55,40.89 24.23,40.57 22.45,40.57 22.13,40.89 22.13,42.86 22.32,43.05 24.29,43.05
+5VALW on BOTTOM (solid shape): 47.66,117.03 47.66,113.72 47.15,113.22 45.12,113.22 44.48,113.85 44.48,117.28 44.74,117.53 47.15,117.53
+5VALW on BOTTOM (solid shape): 52.8,125.47 52.8,123.63 51.22,122.04 50.33,122.04 48.99,123.38 48.99,124.9 50.33,126.23 52.04,126.23
+5VALW on BOTTOM (solid shape): 171.23,60.11 171.23,59.22 171.29,59.16 171.29,58.59 171.17,58.46 170.47,58.46 170.4,58.53 170.4,60.11 170.47,60.18 171.17,60.18
+5VALW on BOTTOM (solid shape): 200.63,41.97 200.63,40.44 200.44,40.25 198.34,40.25 198.15,40.44 198.15,41.84 198.41,42.1 200.5,42.1
+5VALW on BOTTOM (solid shape): 157.26,123.25 159.29,123.25 159.29,123.82 160.18,123.82 160.44,123.57 160.44,120.58 160.05,120.2 157.96,120.2 157.58,120.58 156.31,120.58 155.74,121.15 155.74,122.93 156.63,123.82 157.26,123.82
+5VALW on VCC: 197.5,40.06 194.45,43.11 189.88,43.11 185.84,47.15 185.84,47.71 186.07,47.94 187.59,47.94 188.25,48.59 188.25,50.46 187.34,51.37 181.62,51.37 168.44,64.55 168.44,70.27 160.44,78.27 160.44,97.83 151.93,106.34 151.93,123.61 139.33,136.2 122.86,136.2 121.83,135.17 121.83,131.38 111.43,131.38 109.4,129.34 57.21,129.34 56.3,128.43 56.3,124.77 47,124.77 46.64,125.13 46.64,127.72 55.26,136.33 87.77,136.33 93.99,142.55 146.36,142.55 159.55,129.37 159.55,118.66 156.63,115.73 156.63,106.89 163.48,100.03 163.48,82.63 172.25,73.87 172.25,68.91 184.97,56.19 201.33,56.19 201.33,40.55 200.84,40.06
+5VALW on VCC: 22.62,40.06 21.5,41.19 21.5,52.28 29.37,60.15 29.37,80.34 34.07,85.04 34.07,91.14 43.6,100.66 43.6,114.13 44.21,114.74 50.2,114.74 50.2,98.08 41.56,89.45 41.56,82.44 45.88,78.12 45.88,64.7 41.97,64.7 40.8,63.54 40.8,58.88 41.33,58.35 43.24,58.35 43.34,58.25 43.34,54.41 33.33,54.41 26.58,47.66 26.58,40.06
+5VALWP on TOP (solid shape): 156.12,126.42 156.12,123.5 155.86,123.25 154.72,123.25 154.59,123.38 154.59,126.42 154.72,126.55 155.99,126.55
+5VALWP on BOTTOM (solid shape): 162.02,127.69 162.02,121.28 161.96,121.22 161.01,121.22 160.75,121.47 160.75,123.63 160.37,124.01 156.56,124.01 155.74,123.19 154.78,123.19 154.66,123.31 154.66,128.14 155.23,128.71 161.01,128.71
+5VS on TOP (solid shape): 212.51,31.17 212.51,30.28 212.38,30.16 210.09,30.16 209.97,30.28 209.97,31.17 210.09,31.3 212.38,31.3
+5VS on TOP (solid shape): 222.47,42.78 222.47,41.82 222.35,41.7 221.2,41.7 221.1,41.8 221.1,42.82 221.17,42.89 222.37,42.89
+5VS on TOP (solid shape): 34.9,2.28 34.9,1.33 34.77,1.2 32.29,1.2 32.23,1.27 32.23,2.17 32.25,2.19 33.71,2.19 33.93,2.41 34.77,2.41
+5VS on TOP (solid shape): 23.85,109.41 23.85,108.58 23.47,108.2 23.22,108.2 21.75,106.73 21.69,106.73 21.01,106.05 21.01,105.94 20.54,105.47 16.67,105.47 16.54,105.6 16.54,106.55 16.8,106.8 19.66,106.8 22.45,109.6 23.66,109.6
+5VS on TOP (solid shape): 137.96,143.76 137.96,132.14 137.26,131.44 130.45,131.44 129.26,132.63 128.61,132.63 128.48,132.76 128.48,133.28 127.67,134.09 127.67,134.79 127.73,134.85 128.37,134.85 128.94,135.42 131.34,135.42 131.73,135.82 131.73,144.19 131.87,144.33 137.38,144.33
+5VS on BOTTOM (solid shape): 23.78,109.98 23.78,108.71 23.66,108.58 22.13,108.58 22.01,108.71 22.01,109.6 22.51,110.1 23.66,110.1
+5VS on BOTTOM (solid shape): 182.91,40.32 182.91,38.48 182.79,38.35 179.17,38.35 178.6,38.92 178.6,40.64 178.72,40.76 182.47,40.76
+5VS on BOTTOM (solid shape): 137.32,143.57 137.32,134.36 134.4,131.44 128.75,131.44 128.3,131.88 128.3,134.93 128.94,135.57 130.91,135.57 131.73,136.39 131.73,144.08 131.99,144.33 136.56,144.33
+5VS on IN2 (solid shape): 136.37,144.33 136.37,143.19 136.18,143 130.91,143 130.56,143.35 130.56,144.24 131.03,144.71 135.99,144.71
+5VS on IN2 (solid shape): 25.62,110.04 25.62,108.9 25.03,108.3 22.24,108.3 22.04,108.5 22.04,109.06 23.21,110.23 25.43,110.23
+5VS on TOP: 182.69,71.08 180.48,71.08 179.71,70.32 179.71,68.03 180.32,67.42 181.57,67.42 182.74,68.59 182.74,71.03
+5VS on TOP: 218.12,31.43 217.19,31.43 217.11,31.35 217.11,29.54 216.45,28.89 216.45,28.46 216.56,28.35 217.94,28.35 218.21,28.62 218.21,31.34
+5VS on BOTTOM: 180.16,65.91 179.69,66.39 179.69,66.4 179,67.09 179,68.79 179.49,69.27 179.71,69.27 180.53,68.46 182.05,68.46 182.36,68.16 182.36,67.65 180.62,65.91
+5VS on VCC: outline of 97 points within 33.94,18.85 227.23,148.63
+5VS on IN1: 32.55,1.2 32.04,1.71 32.04,8.44 35.15,11.55 35.15,18.92 36.61,20.38 39.4,20.38 39.66,20.12 39.66,9.84 35.96,6.14 35.21,5.53 34.93,4.6 34.93,1.3 34.83,1.2
+5VS on IN1: 213.52,30.02 213.28,30.02 213.27,30.03 210.09,30.03 209.71,30.41 209.71,32.13 210.28,32.7 221.01,32.7 221.78,33.46 221.78,42.86 222.16,43.24 223.81,43.24 224.19,42.86 224.19,30.28 222.08,28.18 215.36,28.18
+5VS_ODD on BOTTOM (solid shape): 195.5,67.72 195.5,63.79 195.37,63.66 193.02,63.66 192.9,63.79 192.9,67.72 193.09,67.91 195.31,67.91
+5VS_ODD on TOP: 189.47,62.7 186.83,65.34 186.83,65.91 184.45,68.28 183.68,68.28 183.45,68.51 183.45,70.9 183.55,71 185.42,71 185.63,70.86 185.86,70.73 188.79,69.37 188.81,69.35 188.81,66.97 189.08,66.69 190.29,66.69 190.73,66.25 195.08,66.25 195.41,65.92 195.41,63.69 194.42,62.7
+17.4V_BATT+ on TOP (solid shape): 175.74,50.48 175.74,47.37 175.61,47.24 174.47,47.24 174.21,47.49 174.21,50.41 174.41,50.6 175.61,50.6
+17.4V_BATT+ on BOTTOM (solid shape): 176.69,49.59 176.69,47.97 176.69,47.94 177.33,47.94 177.33,49.53 178.53,49.53 178.72,49.33 178.72,42.98 178.02,42.29 176.56,42.29 176.31,42.54 174.72,42.54 174.72,43.3 174.98,43.56 175.8,43.56 176.06,43.81 176.06,46.92 175.61,47.37 174.41,47.37 174.21,47.56 174.21,50.35 174.47,50.6 175.68,50.6
+17.4V_BATT++ on TOP (solid shape): 160.44,43.11 160.44,41.84 159.55,40.95 155.61,40.95 155.36,41.21 155.36,42.6 156.12,43.37 160.18,43.37
+17.4V_BATT++ on TOP (solid shape): 174.34,46.35 174.34,42.67 173.01,41.33 171.74,41.33 171.42,41.65 171.42,43.11 172.12,43.81 172.12,46.35 172.5,46.73 173.96,46.73
+17.4V_BATT++ on BOTTOM (solid shape): 160.31,42.98 160.31,41.97 159.29,40.95 159.29,39.17 159.04,38.92 154.85,38.92 154.59,39.17 154.59,42.98 154.97,43.37 159.93,43.37
+17.4V_BATT++ on BOTTOM (solid shape): 175.87,46.73 175.87,45.91 175.29,45.91 175.29,44.51 175.87,44.51 175.87,43.94 175.68,43.75 174.85,43.75 174.41,43.3 174.41,42.6 174.34,42.54 173.33,42.54 172.12,41.33 171.04,41.33 170.79,41.59 170.79,43.18 171.04,43.43 171.61,43.43 172.22,44.04 172.22,46.58 172.63,46.99 175.61,46.99
+19V_ADPIN on TOP (solid shape): 95.67,147.51 95.67,143.44 95.28,143.06 92.24,143.06 91.86,143.44 91.86,147.25 92.24,147.63 95.54,147.63
+19V_ADPIN on BOTTOM (solid shape): 94.33,145.54 94.33,143.25 94.27,143.19 89.19,143.19 88.81,143.57 88.81,145.35 89.32,145.85 94.01,145.85
+19VB on TOP (solid shape): 203.62,57.53 203.62,55.75 202.98,55.11 200.95,55.11 200.57,55.49 200.57,56.13 201.46,57.02 202.35,57.02 203.04,57.72 203.42,57.72
+19VB on TOP (solid shape): 153.88,143.77 153.88,142.51 153.86,142.5 151.45,142.5 150.99,142.04 141.06,142.04 140.98,142.12 140.98,143.59 141.62,144.24 153.41,144.24
+19VB on TOP (solid shape): 99.41,141.54 99.41,139.89 99.16,139.63 97.38,139.63 97.13,139.89 97.13,140.9 97.7,140.9 97.7,141.41 97.13,141.41 97.13,141.73 97.25,141.85 99.09,141.85
